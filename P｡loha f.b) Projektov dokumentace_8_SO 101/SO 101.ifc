Properties of the parts of a building model (IFC4X3_ADD2), part 15 of 21

# IfcBuiltElement (2093)
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | Linetype | ColorIndex | Layer | PlotStyleName | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | Skupina elementů | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Tloušťka
vozovka_chodník-zpevnění krajnic | 41.2531 | 1 | no | ((-642595.105906586,-1062895.67173388,232.731253982068),(-642580.564207408,-1062887.03277725,233.053215299672)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 2.10845 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1026.85 | 1042.55 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 55.0897 | 1 | no | ((-642548.807139501,-1062921.86292567,232.443129783272),(-642529.184212038,-1062911.48119421,232.796698659321)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 2.8168 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1078.97 | 1100 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 45.9891 | 1 | no | ((-642595.193375362,-1062895.95174044,232.44198449068),(-642580.651298958,-1062887.23128957,232.88823693037)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 2.64714 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1026.85 | 1042.55 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 61.2987 | 1 | no | ((-642548.825951418,-1062922.15049419,232.153860291882),(-642529.262964839,-1062911.70486281,232.631720290054)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 3.53421 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1078.97 | 1100 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 212.345 | 1 | no | ((-642582.120646822,-1062914.38553227,231.335276197865),(-642548.582239612,-1062895.228985,232.771343489755)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 15.9 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1.04261 | 1.07883 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 0.647179 | 1 | no | ((-642686.400398208,-1062834.85780222,233.433182201068),(-642681.443593568,-1062831.22873586,233.498200814009)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00248059 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 3.84146 | 1 | no | ((-642580.521376097,-1062911.49936623,232.756879978631),(-642548.26347275,-1062894.63040483,232.979053796751)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0147424 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1042.61 | 1078.83 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 1.84062 | 1 | no | ((-642686.448046225,-1062834.92284983,233.371172807036),(-642681.443593568,-1062831.22873586,233.458201113906)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0313961 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 10.8861 | 1 | no | ((-642580.559996709,-1062911.57132534,232.69487048496),(-642548.26347275,-1062894.63040483,232.939053796751)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.186549 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1042.61 | 1078.83 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 3.00051 | 1 | no | ((-642686.49869569,-1062834.99199492,233.299036731087),(-642681.443593568,-1062831.22873586,233.398200739271)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0721758 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 17.7122 | 1 | no | ((-642580.601050115,-1062911.6478173,232.622734409011),(-642548.26347275,-1062894.63040483,232.879053796751)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.428859 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1042.61 | 1078.83 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 9.11248 | 1 | no | ((-642686.742738897,-1062835.32515519,233.088744523139),(-642681.443593568,-1062831.22873586,233.328200739184)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.541392 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 53.2718 | 1 | no | ((-642580.79885684,-1062912.01637685,232.412442201218),(-642548.26347275,-1062894.63040483,232.809053796751)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 3.21688 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1042.61 | 1078.83 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 29.3427 | 1 | no | ((-642687.653213985,-1062836.56810774,232.750927965502),(-642681.443593568,-1062831.22873586,233.128200738908)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 2.55215 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 154.925 | 1 | no | ((-642581.446231006,-1062913.22258421,232.097782654571),(-642548.26347275,-1062894.63040483,232.609053796751)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 13.09 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1042.61 | 1078.83 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 22.9875 | 1 | no | ((-642687.429612201,-1062836.26285347,233.182690665292),(-642681.443593568,-1062831.22873586,233.498200814009)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 1.41201 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 94.4687 | 1 | no | ((-642581.150551789,-1062912.57364839,232.549287264716),(-642548.26347275,-1062894.60158408,232.979053796797)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 4.86362 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1042.61 | 1078.83 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 22.984 | 1 | no | ((-642687.513496764,-1062836.37737009,232.90806632271),(-642681.550063697,-1062831.37469859,233.333222369713)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 1.99771 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 919.96 | 926.04 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 105.614 | 1 | no | ((-642581.251355437,-1062912.85948609,232.260017773293),(-642548.344230343,-1062894.78935293,232.814075427543)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 6.10333 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1042.61 | 1078.83 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 10.09 | 1 | no | ((-642609.728622436,-1062913.10828565,232.65072249723),(-642525.48195636,-1062867.99517829,233.172668419638)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0387125 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1004.01 | 1100 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 28.5783 | 1 | no | ((-642609.728622436,-1062913.10828565,232.58871300356),(-642525.44702942,-1062867.92636672,233.132668419638)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.49004 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1004.01 | 1100 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 46.4832 | 1 | no | ((-642609.728622436,-1062913.10828565,232.51657692761),(-642525.409902357,-1062867.85322056,233.072668419638)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.12642 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1004.01 | 1100 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 139.581 | 1 | no | ((-642609.728622436,-1062913.10828565,232.306284719818),(-642525.231013848,-1062867.50078201,233.002668419638)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 8.44672 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1004.01 | 1100 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 457.979 | 1 | no | ((-642609.728622436,-1062913.10828565,231.991625173174),(-642524.645554484,-1062865.79203905,232.802668419638)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 38.2969 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1004.01 | 1100 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 1119.32 | 1 | no | ((-642609.143825208,-1062912.46396379,231.667387648603),(-642522.796411154,-1062863.16557966,234.050053880141)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 78.8516 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1004.01 | 1100 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 309.254 | 1 | no | ((-642609.901198994,-1062913.10828565,232.443129783285),(-642524.960529807,-1062866.22163546,233.172668419712)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 17.3599 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1004.01 | 1100 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 329.223 | 1 | no | ((-642609.634950474,-1062912.94505073,232.153860291898),(-642524.821792173,-1062866.13925506,233.007690050421)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 23.5702 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1004.01 | 1100 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 0.63881 | 1 | no | ((-642679.274956433,-1062825.13036844,233.52068230069),(-642674.382218243,-1062821.54810914,233.585700738903)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00244849 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 1.81677 | 1 | no | ((-642679.274956349,-1062825.13036841,233.458672806898),(-642674.334998643,-1062821.48337455,233.545700738903)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0309876 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 2.96145 | 1 | no | ((-642679.274956343,-1062825.13036841,233.386536730739),(-642674.284804579,-1062821.41456217,233.485700738904)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0712297 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 8.99184 | 1 | no | ((-642679.274956344,-1062825.13036841,233.176244523124),(-642674.042955622,-1062821.08300503,233.415700739052)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.534124 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 32.3706 | 1 | no | ((-642679.274956343,-1062825.13036841,232.842125517032),(-642672.870388918,-1062819.5783033,233.215700738904)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 2.56685 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 23.156 | 1 | no | ((-642679.274956433,-1062825.13036844,233.253089586499),(-642673.23668142,-1062820.14981882,233.585700739188)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 1.41003 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 24.0603 | 1 | no | ((-642679.167520231,-1062824.98369994,233.004360635752),(-642673.108654087,-1062819.90494714,233.420722369709)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 1.94799 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 919.96 | 926.04 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 217.236 | 1 | no | ((-642859.219305052,-1062739.41675577,232.76698794183),(-642834.914408886,-1062725.96171213,232.993378872655)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 4.29711 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 707.98 | 732.03 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 218.392 | 1 | no | ((-642859.219305052,-1062739.41675577,232.70698794183),(-642834.914408886,-1062725.96171213,232.953378872655)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 6.44566 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 707.98 | 732.03 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 218.97 | 1 | no | ((-642859.219305052,-1062739.41675577,232.63698794183),(-642834.914408886,-1062725.96171213,232.893378872655)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 7.51994 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 707.98 | 732.03 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 226.484 | 1 | no | ((-642859.219305052,-1062739.41675577,232.43698794183),(-642834.914408886,-1062725.96171213,232.823378872655)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 21.4855 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 707.98 | 732.03 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 230.022 | 1 | no | ((-642859.219305052,-1062739.41675577,232.165671499616),(-642834.914408886,-1062725.96171213,232.623378872655)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 28.034 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 707.98 | 732.03 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 2.5887 | 1 | no | ((-642859.226979712,-1062739.43549851,232.766481612716),(-642836.619595853,-1062729.90705625,232.880880617993)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00993128 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 707.99 | 731.64 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 7.33809 | 1 | no | ((-642859.257438517,-1062739.50988375,232.704472119045),(-642836.619595853,-1062729.90705625,232.840880617993)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.125693 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 707.99 | 731.64 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 11.9411 | 1 | no | ((-642859.289815987,-1062739.58895468,232.632336043096),(-642836.619595853,-1062729.90705625,232.780880617993)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.288938 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 707.99 | 731.64 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 35.9421 | 1 | no | ((-642859.445819639,-1062739.96994041,232.422043835303),(-642836.619595853,-1062729.90705625,232.710880617993)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 2.16699 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 707.99 | 731.64 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 64.7534 | 1 | no | ((-642859.647274047,-1062740.46364396,232.131789632666),(-642836.619595853,-1062729.90705625,232.510880617993)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 6.14192 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 707.99 | 731.64 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 68.4146 | 1 | no | ((-642859.692975447,-1062740.80488989,232.556508707382),(-642836.619595853,-1062729.90705625,232.880880617993)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 4.2822 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 707.99 | 731.64 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 1401.93 | 1 | no | ((-642836.617619187,-1062819.12057768,232.840883564135),(-642700.342090731,-1062735.2532306,233.649878665549)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 27.7718 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 731.64 | 900 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 1408.37 | 1 | no | ((-642836.617619187,-1062819.12057768,232.780883564135),(-642700.342090731,-1062735.2532306,233.609878665549)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 41.6577 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 731.64 | 900 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 1411.6 | 1 | no | ((-642836.617619187,-1062819.12057768,232.710883564135),(-642700.342090731,-1062735.2532306,233.549878665549)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 48.6007 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 731.64 | 900 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 1453.48 | 1 | no | ((-642836.617619187,-1062819.12057768,232.510883564135),(-642700.342090731,-1062735.2532306,233.479878665549)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 138.859 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 731.64 | 900 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 1473.23 | 1 | no | ((-642836.617619187,-1062819.12057768,232.238383809714),(-642700.342090731,-1062735.2532306,233.279878665549)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 181.254 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 731.64 | 900 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 3.29349 | 1 | no | ((-642836.625293847,-1062752.15786096,232.840377235021),(-642808.138437709,-1062739.41758753,232.982499999996)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.012635 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 731.64 | 760.89 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 9.33321 | 1 | no | ((-642836.655752652,-1062752.23018276,232.77836774135),(-642808.138437709,-1062739.41758753,232.942499999996)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.159919 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 731.63 | 760.89 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 15.1847 | 1 | no | ((-642836.688130122,-1062752.30706026,232.706231665401),(-642808.138437709,-1062739.41758753,232.882499999996)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.367583 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 731.62 | 760.89 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 45.6599 | 1 | no | ((-642836.844133774,-1062752.67747746,232.495939457609),(-642808.138437709,-1062739.41758753,232.812499999996)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 2.756 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 731.59 | 760.89 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 173.314 | 1 | no | ((-642837.601772934,-1062754.47642682,232.160469365643),(-642808.138437709,-1062739.41758753,232.612499999996)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 14.2713 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 731.42 | 760.89 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 269.025 | 1 | no | ((-642838.628175417,-1062756.53053161,231.639468165163),(-642808.777936863,-1062740.7736913,232.832243681375)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 18.5187 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 731.19 | 760.53 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 127.766 | 1 | no | ((-642837.364217557,-1062753.91237149,232.572784521075),(-642808.138437709,-1062739.41758753,232.982499999996)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 7.67385 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 731.47 | 760.89 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 131.118 | 1 | no | ((-642837.448080988,-1062754.11149856,232.322704484367),(-642808.217530941,-1062739.58531039,232.81752163078)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 11.0428 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 731.45 | 760.85 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 1627.72 | 1 | no | ((-642814.908703708,-1062826.70657918,229.594726951382),(-642703.351450235,-1062751.32440545,233.287554575235)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 125.4 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 0.75531 | 0.9 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 13.728 | 1 | no | ((-642812.616078156,-1062819.13661606,232.917095959592),(-642702.470262243,-1062749.99959098,233.553970253811)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0526138 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 756.36 | 900 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 38.8902 | 1 | no | ((-642812.650398331,-1062819.20036859,232.855489898986),(-642702.470262243,-1062749.99959098,233.513970253811)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.667004 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 756.34 | 900 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 63.253 | 1 | no | ((-642812.686877007,-1062819.26813072,232.783782828279),(-642702.470262243,-1062749.99959098,233.453970253811)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.5332 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 756.32 | 900 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 189.343 | 1 | no | ((-642812.861795743,-1062819.5930566,232.575597261269),(-642702.470262243,-1062749.99959098,233.383970253811)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 11.4708 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 756.23 | 900 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 685.39 | 1 | no | ((-642813.717422195,-1062820.8539146,232.23708553601),(-642702.470262243,-1062749.99959098,233.183970253811)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 57.0401 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 755.78 | 900.01 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 505.885 | 1 | no | ((-642813.44949509,-1062820.51504954,232.649400957001),(-642702.470262243,-1062749.99959098,233.553970253811)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 31.0201 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 755.92 | 900.01 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 515.327 | 1 | no | ((-642813.544080741,-1062820.60089685,232.399320654729),(-642702.580622895,-1062750.16367942,233.388971051261)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 43.4888 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 755.87 | 900.01 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrubník | 19.9212 | 1 | no | ((-642791.414101951,-1062720.07150146,233.158741074883),(-642784.2742359,-1062715.09346092,233.49903360942)) | ByLayer | 40 | vozovka_chodník-obrubník | Barva_40 |  |  |  |  | P2 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 776.56 | 783.54 | obrubník | 91726 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obruba; Stavební výrobek: obrubník KO; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 18.47
vozovka_chodník-obrubník | 22.5608 | 1 | no | ((-642791.414101951,-1062720.07150146,233.058741074883),(-642784.2742359,-1062715.09346092,233.34903360942)) | ByLayer | 40 | vozovka_chodník-obrubník | Barva_40 |  |  |  |  | P2 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0.77656 | 0.78354 | obrubník | nerelevantni | nerelevantni | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obruba; Stavební výrobek: lože; Specifikace: C20/25nXF3; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 0
vozovka_chodník-spodní podkladní vrstva | 24.0208 | 1 | no | ((-642791.414101951,-1062720.07150146,232.808741074883),(-642784.2742359,-1062715.09346092,233.09903360942)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 1.90989 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 776.56 | 783.54 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-obrusná vrstva | 402.128 | 2 | yes | ((-642813.766917733,-1062750.16486982,233.029989953264),(-642792.349030187,-1062725.67175659,233.382683784314)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 7.9539 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 753.5 | 773.12 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 404.254 | 2 | yes | ((-642813.766917733,-1062750.16486982,232.969989953264),(-642792.349030187,-1062725.67175659,233.342683784314)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 11.9308 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 753.5 | 773.12 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 405.317 | 2 | yes | ((-642813.766917733,-1062750.16486982,232.899989953264),(-642792.349030187,-1062725.67175659,233.282683784314)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 13.9193 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 753.5 | 773.12 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 413.811 | 2 | yes | ((-642813.766537848,-1062750.16310856,232.750036360729),(-642792.348650303,-1062725.67056278,233.212730191779)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 29.8259 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 753.5 | 773.12 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 436.387 | 2 | yes | ((-642813.766537848,-1062750.16310856,232.500036360729),(-642792.348650303,-1062724.6196525,233.062730191779)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 51.1627 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 753.5 | 773.12 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 159.968 | 2 | no | ((-642802.554242203,-1062726.30427977,233.143),(-642787.060441263,-1062712.07661993,233.373636328501)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 3.1585 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 759.73 | 780.63 | obrusná vrstva | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 160.471 | 2 | no | ((-642802.554242203,-1062726.30427977,233.093),(-642787.060441263,-1062712.07661993,233.333636328501)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 3.94812 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 759.73 | 780.63 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-podkladní asfaltová vrstva | 160.974 | 2 | no | ((-642802.554242203,-1062726.30427977,233.033),(-642787.060441263,-1062712.07661993,233.283636328501)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 5.68524 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 759.73 | 780.63 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-horní podkladní vrstva | 165.498 | 2 | no | ((-642802.554242203,-1062726.30427977,232.883),(-642787.060441263,-1062712.07661993,233.223636328501)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 11.8444 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 759.73 | 780.63 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 3.17894 | 2 | no | ((-642786.426065124,-1062719.11099343,232.871809588634),(-642782.997405243,-1062717.22417727,233.084049475082)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 0.146713 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 781.29 | 784.81 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 36.1588 | 1 | no | ((-642782.99721547,-1062718.37566963,233.240103111753),(-642769.889941197,-1062713.79440242,233.42)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.698445 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 784.81 | 788.79 | obrusná vrstva | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-podkladní asfaltová vrstva | 36.7623 | 1 | no | ((-642782.99721547,-1062718.37566963,233.130103111753),(-642769.889941197,-1062713.79440242,233.33)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.25724 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 784.81 | 788.79 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 36.4605 | 1 | no | ((-642782.99721547,-1062718.37566963,233.190103111753),(-642769.889941197,-1062713.79440242,233.38)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.873056 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 784.81 | 788.79 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-horní podkladní vrstva | 39.478 | 1 | no | ((-642782.99721547,-1062718.37566963,232.980103111753),(-642769.889941197,-1062713.79440242,233.27)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 2.61917 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 784.81 | 788.79 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 40.9868 | 1 | no | ((-642782.99721547,-1062718.37566963,232.830103111753),(-642769.889941197,-1062713.79440242,233.17)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 3.49222 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 784.81 | 788.79 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
zemní práce-rozprostření ornice (ohumusovani) | 13.4238 | 1 | no | ((-642756.706373238,-1062753.39702673,232.268821282781),(-642753.689666919,-1062750.12271264,233.192520250815)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 0.826025 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 814.26 | 817.67 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 0.327721 | 1 | no | ((-642757.393886516,-1062753.73181304,233.329493670885),(-642756.239435878,-1062750.85030218,233.399999999999)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00125441 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 813.88 | 816.7 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 0.933378 | 1 | no | ((-642757.393886516,-1062753.73181304,233.267484177214),(-642756.168401088,-1062750.8291996,233.359999999999)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0158348 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 813.88 | 816.73 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 1.52038 | 1 | no | ((-642757.393886516,-1062753.73181304,233.195348101265),(-642756.092891665,-1062750.80676773,233.299999999999)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0362928 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 813.88 | 816.76 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 4.61142 | 1 | no | ((-642757.393886516,-1062753.73181304,232.985055893473),(-642755.729066274,-1062750.69868473,233.229999999999)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.269341 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 813.88 | 816.9 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 12.5707 | 1 | no | ((-642757.393886516,-1062753.73181304,232.67174769818),(-642754.541338277,-1062750.38091324,233.029999999999)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 1.02596 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 813.88 | 817.35 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 7.76066 | 1 | no | ((-642757.393886516,-1062753.73181304,233.121900956945),(-642755.178952898,-1062750.55026441,233.399999999999)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 0.391215 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 813.88 | 817.11 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 8.45881 | 1 | no | ((-642757.219004803,-1062753.64699702,232.833982816903),(-642754.899772399,-1062750.47601563,233.235021630785)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.464113 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 813.98 | 817.21 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 80.0882 | 1 | no | ((-642757.113322227,-1062750.66856078,232.110624463346),(-642740.869846854,-1062737.31007762,233.24283515929)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 5.0557 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 806.2 | 817.88 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-ložní vrstva | 8.63259 | 1 | no | ((-642757.823114827,-1062750.85561936,232.85),(-642741.556369991,-1062736.63737173,233.3)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | beton C20/25nXF3 | nerelevantni | P2 | 128;128;128 | 0.177372 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 805.5 | 815.91 | ložní vrstva | 45131A | I1+S1+E1+Z1+M3;2&6+F1 | 0.1 | CZ_S4 - Specifikace: nerelevantni; Beton: C20/25nXF3; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.1.4; Návrhová životnost: 25 let
vozovka_chodník-spodní podkladní vrstva | 64.4693 | 1 | no | ((-642757.823114827,-1062750.85561936,232.579959899895),(-642741.166272515,-1062736.63737173,233.2)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 4.34245 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 805.5 | 817.03 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-zpevnění krajnic | 53.8381 | 1 | no | ((-642757.823114827,-1062750.85561936,232.860858054249),(-642741.237763658,-1062736.63737173,233.45)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 3.15073 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 805.5 | 816.83 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 45.6375 | 1 | no | ((-642757.771439061,-1062750.842051,232.73960616034),(-642741.267102848,-1062736.68640896,233.295386213991)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 2.39338 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 805.55 | 816.74 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 128.377 | 1 | no | ((-642760.679617415,-1062729.37174743,232.014917795168),(-642742.746227403,-1062722.01716018,233.23228969299)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 8.49754 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 789.17 | 799.89 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 2.11312 | 1 | no | ((-642761.211427157,-1062730.08712751,233.079291971473),(-642742.65965921,-1062725.10669501,233.440000000002)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00810548 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 789.4 | 800.53 | obrusná vrstva | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-podkladní asfaltová vrstva | 6.50928 | 1 | no | ((-642761.211427157,-1062730.08712751,233.007155895523),(-642742.65965921,-1062725.04954536,233.400000000002)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.123005 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 789.37 | 800.53 | podkladní asfaltová vrstva | 574FE06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 21.4437 | 1 | no | ((-642761.211427157,-1062730.08712751,232.848811739679),(-642742.65965921,-1062724.82630159,233.330000000001)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.960732 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 789.26 | 800.53 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 68.1174 | 1 | no | ((-642761.211427157,-1062730.08712751,232.579654112735),(-642742.65965921,-1062724.11071989,233.180000000002)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 4.95364 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 789.05 | 800.53 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 55.3094 | 1 | no | ((-642761.211427157,-1062730.08712751,232.820658650032),(-642742.65965921,-1062724.30406357,233.440000000002)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 2.93619 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 789.16 | 800.53 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 37.6788 | 1 | no | ((-642760.99288734,-1062729.79315201,232.739300373182),(-642742.695614998,-1062724.38200241,233.266002452216)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 1.5476 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 789.05 | 800.26 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 110.267 | 1 | no | ((-642769.608781802,-1062724.64174502,232.06316116937),(-642757.732095135,-1062713.89857827,233.232289692997)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 7.57113 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 0.789 | 0.79 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 1.17622 | 1 | no | ((-642769.889941197,-1062725.1202416,233.379493670886),(-642761.196371238,-1062718.3570462,233.440000000002)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0045106 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0.789 | 0.79 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 3.34342 | 1 | no | ((-642769.889941197,-1062725.1202416,233.317484177215),(-642761.136618057,-1062718.2831345,233.400000000002)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.057168 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0.789 | 0.79 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 5.45321 | 1 | no | ((-642769.889941197,-1062725.1202416,233.245348101266),(-642761.073100897,-1062718.20456694,233.340000000002)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.131628 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0.789 | 0.79 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 16.5839 | 1 | no | ((-642769.889941197,-1062725.1202416,233.035055893474),(-642760.767057561,-1062717.82600659,233.270000000002)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.992776 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0.789 | 0.79 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 49.4292 | 1 | no | ((-642769.889941197,-1062725.1202416,232.721747698178),(-642759.767962258,-1062716.5901755,233.070000000001)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 4.09938 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0.789 | 0.79 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 29.6895 | 1 | no | ((-642769.889941197,-1062725.1202416,233.171900956895),(-642760.304312141,-1062717.25361357,233.440000000002)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 1.51899 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0.789 | 0.79 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 33.4989 | 1 | no | ((-642769.81871122,-1062724.99901748,232.883982816901),(-642760.069470557,-1062716.96312624,233.275021630792)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 1.91933 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 0.789 | 0.79 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 1.33447 | 1 | no | ((-642781.662756015,-1062718.37566963,233.239596782639),(-642769.881981371,-1062713.77529725,233.42)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00511852 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 786.43 | 788.64 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 3.45204 | 1 | no | ((-642781.662756015,-1062718.37566963,233.187713871246),(-642769.852380766,-1062713.70424992,233.38)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0523902 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 786.43 | 788.67 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-podkladní asfaltová vrstva | 5.70207 | 1 | no | ((-642781.662756015,-1062718.37566963,233.125704377575),(-642769.820790206,-1062713.6284263,233.33)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.14628 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 786.43 | 788.7 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-horní podkladní vrstva | 15.512 | 1 | no | ((-642781.662756015,-1062718.37566963,232.967360221731),(-642769.689614593,-1062713.31357877,233.27)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.745299 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 786.43 | 788.84 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 45.0516 | 1 | no | ((-642781.662756015,-1062718.37566963,232.711580539662),(-642769.254268935,-1062712.2686627,233.12)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 3.29659 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 786.43 | 788.93 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
zemní práce-rozprostření ornice (ohumusovani) | 111.99 | 1 | no | ((-642781.425324558,-1062717.71784749,232.108177634556),(-642767.976428936,-1062709.94476748,233.212289692994)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 7.66698 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 786.71 | 788.99 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 32.9817 | 1 | no | ((-642781.662756015,-1062718.37566963,233.032004068693),(-642769.410363844,-1062712.64332149,233.42)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 1.66768 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 786.43 | 788.94 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
