Properties of the parts of a building model (IFC4X3_ADD2), part 16 of 21

# IfcBuiltElement (2093)
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | Linetype | ColorIndex | Layer | PlotStyleName | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | Skupina elementů | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Tloušťka
zemní práce-zemní krajnice a dosypávky | 24.5663 | 1 | no | ((-642781.562313481,-1062718.09738585,232.873815658385),(-642769.413671602,-1062712.65126076,233.24530984578)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 1.08508 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 786.55 | 788.93 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 0.174784 | 1 | no | ((-642802.55935464,-1062716.87206081,233.142493670886),(-642801.027218206,-1062716.24070287,233.189783943472)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.000667498 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 759.73 | 761.49 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 0.454846 | 1 | no | ((-642802.578366515,-1062716.9378275,233.090610759494),(-642801.027218206,-1062716.24070287,233.149783943472)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00679459 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 759.72 | 761.49 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-podkladní asfaltová vrstva | 0.751531 | 1 | no | ((-642802.598656499,-1062717.00801549,233.028601265823),(-642801.027218206,-1062716.24070287,233.099783943472)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.01884 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 759.72 | 761.49 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-horní podkladní vrstva | 2.05464 | 1 | no | ((-642802.682907965,-1062717.29946178,232.870257109979),(-642801.027218206,-1062716.24070287,233.039783943472)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.0941787 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 759.69 | 761.49 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 5.63169 | 1 | no | ((-642802.962521753,-1062718.26671383,232.614477427909),(-642801.027218206,-1062716.24070287,232.889783943472)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 0.386513 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 759.61 | 761.49 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
zemní práce-rozprostření ornice (ohumusovani) | 7.04227 | 1 | no | ((-642803.351998745,-1062719.69367927,232.235755336496),(-642801.375865135,-1062716.93292418,232.982073636466)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 0.408558 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 759.5 | 761.24 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 4.13119 | 1 | no | ((-642802.862265122,-1062717.91990178,232.93490095694),(-642801.027218206,-1062716.24070287,233.189783943472)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 0.19858 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 759.64 | 761.49 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 2.97636 | 1 | no | ((-642802.860140616,-1062717.9125526,232.776712546633),(-642801.174709114,-1062716.5335388,233.015093789252)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.125222 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 759.64 | 761.38 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 56.4531 | 1 | no | ((-642802.698025334,-1062727.5358531,232.143234928052),(-642798.411913714,-1062717.47905628,233.012289692995)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 3.64297 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 760.36 | 765.3 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-ložní vrstva | 4.91237 | 1 | no | ((-642801.075648945,-1062728.15490608,232.887698658292),(-642797.696712099,-1062716.85437564,233.07)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | beton C20/25nXF3 | nerelevantni | P2 | 128;128;128 | 0.100827 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 761.45 | 766.02 | ložní vrstva | 45131A | I1+S1+E1+Z1+M3;2&6+F1 | 0.1 | CZ_S4 - Specifikace: nerelevantni; Beton: C20/25nXF3; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.1.4; Návrhová životnost: 25 let
vozovka_chodník-spodní podkladní vrstva | 40.8405 | 1 | no | ((-642801.762785944,-1062728.15490608,232.612419329444),(-642797.696712099,-1062716.85437564,232.97)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 2.71228 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 760.96 | 766.02 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-zpevnění krajnic | 33.1633 | 1 | no | ((-642801.621909953,-1062728.15490608,232.889599615239),(-642797.696712099,-1062716.85437564,233.22)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 1.87201 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 761.06 | 766.02 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 28.0224 | 1 | no | ((-642801.565121376,-1062728.11018376,232.774654448167),(-642797.748380499,-1062716.89950453,233.065386213995)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 1.43255 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 761.1 | 765.96 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 61.4281 | 1 | no | ((-642811.077878887,-1062728.58970629,232.008197001618),(-642801.29583563,-1062725.04441399,232.929988351287)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 4.06008 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 753.1 | 763.22 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 1.09932 | 1 | no | ((-642811.160233609,-1062729.30509292,233.029493670886),(-642800.937291376,-1062728.13738024,233.137698658292)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00421548 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 753.5 | 763.69 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 3.11345 | 1 | no | ((-642811.160233609,-1062729.30509292,232.967484177215),(-642800.937291376,-1062728.06782457,233.097698658292)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0532324 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 753.49 | 763.69 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 5.05742 | 1 | no | ((-642811.160233609,-1062729.30509292,232.895348101266),(-642800.937291376,-1062727.99388744,233.037698658292)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.122057 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 753.48 | 763.69 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 15.1177 | 1 | no | ((-642811.160233609,-1062729.30509292,232.685055893474),(-642800.937291376,-1062727.63763778,232.967698658292)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.907164 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 753.44 | 763.69 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 42.2376 | 1 | no | ((-642811.160233609,-1062729.30509292,232.37174769818),(-642800.937291376,-1062726.47464118,232.767698658292)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 3.55457 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 753.31 | 763.69 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 26.1745 | 1 | no | ((-642811.160233609,-1062729.30509292,232.821900956924),(-642800.937291376,-1062727.09897911,233.137698658292)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 1.34376 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 753.38 | 763.69 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 28.777 | 1 | no | ((-642811.139369554,-1062729.12385418,232.533982816905),(-642801.028126323,-1062726.82561183,232.972720289081)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 1.64368 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 753.35 | 763.58 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 1291.03 | 1 | no | ((-642797.34993639,-1062756.9318311,233.279999999833),(-642757.351387637,-1062716.93299452,233.670000000018)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 25.632 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 768.44 | 809.78 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 1295.55 | 1 | no | ((-642797.34993639,-1062756.9318311,233.219999999833),(-642757.351387637,-1062716.93299452,233.630000000018)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 38.448 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 768.44 | 809.78 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 1297.8 | 1 | no | ((-642797.34993639,-1062756.9318311,233.149999999833),(-642757.351387637,-1062716.93299452,233.570000000018)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 44.856 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 768.44 | 809.78 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 1327.13 | 1 | no | ((-642797.34993639,-1062756.9318311,232.949999999833),(-642757.351387637,-1062716.93299452,233.500000000018)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 128.16 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 768.44 | 809.78 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 1342.45 | 1 | no | ((-642797.34993639,-1062756.9318311,232.669999999833),(-642757.351387637,-1062716.93299452,233.300000000018)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 170.377 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 768.44 | 809.78 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrubník | 98.8901 | 1 | no | ((-642791.350250263,-1062750.93184511,233.249999999833),(-642763.351266135,-1062722.93265949,233.750000000018)) | ByLayer | 40 | vozovka_chodník-obrubník | Barva_40 |  |  |  |  | P2 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 775.04 | 803.04 | obrubník | 91726 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obruba; Stavební výrobek: obrubník KO; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 88
vozovka_chodník-obrubník | 78.0252 | 1 | no | ((-642789.850328731,-1062749.43184861,233.485999999833),(-642764.85123576,-1062724.43257574,233.986000000018)) | ByLayer | 40 | vozovka_chodník-obrubník | Barva_40 |  |  |  |  | P2 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 776.54 | 801.54 | obrubník | 91726 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obruba; Stavební výrobek: obrubník KO; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 78.5
vozovka_chodník-obrubník | 115.075 | 1 | no | ((-642791.350250263,-1062750.93184511,233.149999999833),(-642763.351266135,-1062722.93265949,233.600000000018)) | ByLayer | 40 | vozovka_chodník-obrubník | Barva_40 |  |  |  |  | P2 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0.77504 | 0.80304 | obrubník | nerelevantni | nerelevantni | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obruba; Stavební výrobek: lože; Specifikace: C20/25nXF3; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 0
vozovka_chodník-obrubník | 97.4238 | 1 | no | ((-642789.850328731,-1062749.43184861,233.335999999833),(-642764.85123576,-1062724.43257574,233.836000000018)) | ByLayer | 40 | vozovka_chodník-obrubník | Barva_40 |  |  |  |  | P2 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0.77654 | 0.80154 | obrubník | nerelevantni | nerelevantni | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obruba; Stavební výrobek: lože; Specifikace: C20/25nXF3; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 0
vozovka_chodník-CBK | 233.688 | 1 | no | ((-642791.050265956,-1062750.63184581,233.299999999833),(-642763.65126006,-1062723.23264274,233.786000000018)) | ByLayer | 9 | vozovka_chodník-CBK | Barva_9 | nerelevantni | D1.1.4 | beton C30/37 XF4, XD4 | nerelevantni | P2 | 191;191;191 | 24.462 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 775.34 | 802.74 | CBK | 451315 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 299.575 | 1 | no | ((-642791.350250263,-1062750.93184511,232.849999999833),(-642763.351266135,-1062722.93265949,233.381500000018)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 36.0372 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 775.04 | 803.04 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 204.411 | 1 | no | ((-642789.850328731,-1062749.43184861,232.894999999833),(-642764.85123576,-1062724.43257574,233.536000000018)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 24.8318 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 776.54 | 801.54 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 196.783 | 1 | no | ((-642790.900273803,-1062750.48184616,233.149999999833),(-642763.801257023,-1062723.38263437,233.531500000018)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 12.8878 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 775.49 | 802.59 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-násyp | 938.296 | 1 | no | ((-642789.50034704,-1062749.08184942,232.926909090742),(-642765.201228673,-1062724.78255619,234.036000000018)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 281.813 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 776.89 | 801.19 | násyp | 17110 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 995.604 | 1 | no | ((-642789.650339193,-1062749.23184907,233.335999999833),(-642765.05123171,-1062724.63256457,234.486000000018)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 210.681 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 776.74 | 801.34 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.5
vozovka_chodník-obrusná vrstva | 208.609 | 2 | yes | ((-642781.891419575,-1062765.37069973,233.292616918255),(-642756.257334408,-1062744.13874554,233.545593208484)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 4.09877 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 803.32 | 816.7 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 210.386 | 2 | yes | ((-642781.891419575,-1062765.37069973,233.232616918255),(-642756.257334408,-1062744.13874554,233.505593208484)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 6.14815 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 803.32 | 816.7 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 211.275 | 2 | yes | ((-642781.891419575,-1062765.37069973,233.162616918255),(-642756.257334408,-1062744.13874554,233.445593208484)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 7.17284 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 803.32 | 816.7 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 222.828 | 2 | yes | ((-642781.891419575,-1062765.37069973,232.962616918255),(-642756.257334408,-1062744.13874554,233.375593208484)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 20.4938 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 803.32 | 816.7 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 237.243 | 2 | yes | ((-642781.891419575,-1062765.37069973,232.712616918255),(-642756.257334408,-1062744.13874554,233.175593208484)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 26.8477 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 803.32 | 816.7 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 271.31 | 2 | yes | ((-642761.205869142,-1062744.16770955,233.059999999998),(-642741.587751918,-1062725.1263595,233.489057214567)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 5.36 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 789.34 | 815.82 | obrusná vrstva | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-podkladní asfaltová vrstva | 273.695 | 2 | yes | ((-642761.205869142,-1062744.16770955,232.99),(-642741.587751918,-1062725.1263595,233.449057214567)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 9.38 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 789.34 | 815.82 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 280.057 | 2 | yes | ((-642761.205869142,-1062744.16770955,232.84),(-642741.587751918,-1062725.1263595,233.379057214567)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 20.1 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 789.34 | 815.82 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 340.944 | 2 | yes | ((-642761.205869142,-1062744.91335082,232.64),(-642741.587751918,-1062725.1263595,233.229057214567)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 32.4917 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 789.34 | 815.82 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-kryt z dlažebních dílců | 469.715 | 1 | no | ((-642818.8523242,-1062772.82290817,233.070000000003),(-642759.746338537,-1062740.67853986,233.56)) | ByLayer | 9 | vozovka_chodník-kryt z dlažebních dílců | Barva_9 | nerelevantni | D1.1.4 | bet. dlažba tl. 80 mm v loži HDK | TP 192 | P2 | 191;191;191 | 18.3347 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 748.71 | 826.72 | kryt z dlažebních dílců | 582612 | I1+S1+E1+Z1+M3;2&6+F1 | 0.08
vozovka_chodník-ložní vrstva | 464.245 | 1 | no | ((-642818.8523242,-1062772.82290817,233.030000000003),(-642759.746338537,-1062740.67853986,233.48)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | lože HDK | TP 192 | P2 | 128;128;128 | 9.16733 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 748.71 | 826.72 | ložní vrstva | nerelevantni | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-spodní podkladní vrstva | 492.963 | 1 | no | ((-642818.8523242,-1062772.82290817,232.780000000003),(-642759.746338537,-1062740.67853986,233.44)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 57.2958 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 748.71 | 826.72 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-kryt z dlažebních dílců | 11.9559 | 1 | no | ((-642757.187422144,-1062736.61016805,233.399081802812),(-642753.376922624,-1062734.15443746,233.589649724311)) | ByLayer | 9 | vozovka_chodník-kryt z dlažebních dílců | Barva_9 | nerelevantni | D1.1.4 | žul. kostka malá do lože z HDK | TP 192 | P2 | 191;191;191 | 0.545305 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 797.22 | 799.61 | kryt z dlažebních dílců | 58221 | I1+S1+E1+Z1+M3;2&6+F1 | 0.1
vozovka_chodník-ložní vrstva | 11.3285 | 1 | no | ((-642757.187422144,-1062736.61016805,233.359081802812),(-642753.376922624,-1062734.15443746,233.489649724311)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | lože HDK | TP 192 | P2 | 128;128;128 | 0.218122 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 797.22 | 799.61 | ložní vrstva | nerelevantni | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-spodní podkladní vrstva | 13.5246 | 1 | no | ((-642757.188257121,-1062736.6093923,233.109114303624),(-642753.377757601,-1062734.15366171,233.449682225123)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.36326 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 797.22 | 799.61 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 13.4551 | 1 | no | ((-642757.187422144,-1062736.61016805,232.849081802812),(-642753.495352484,-1062734.15443746,233.199649724311)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.40134 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 797.22 | 799.61 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 476.9 | 1 | no | ((-642818.702424552,-1062772.71362867,232.500000000003),(-642759.746338537,-1062740.67853986,233.19)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 61.269 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 748.86 | 826.72 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 36.1904 | 2 | no | ((-642837.062635644,-1062742.29091174,232.949635189398),(-642817.9897306,-1062734.37277555,233.06870679073)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.689102 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 729.77 | 749.33 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 37.0505 | 2 | no | ((-642837.062635644,-1062742.29091174,232.889635189398),(-642817.9897306,-1062734.37277555,233.02870679073)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.03365 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 729.77 | 749.33 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 37.4806 | 2 | no | ((-642837.062635644,-1062742.29091174,232.819635189398),(-642817.9897306,-1062734.37277555,232.96870679073)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.20593 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 729.77 | 749.33 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 42.9526 | 2 | no | ((-642760.973379681,-1062783.84938109,232.983104359997),(-642744.187574356,-1062771.37895754,233.350010112203)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 3.43468 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 826.02 | 845.8 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 45.0909 | 2 | no | ((-642760.973834959,-1062783.85088471,232.733099574659),(-642744.188029634,-1062771.39374699,233.150005326865)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 4.29362 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 826.04 | 845.8 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
záchytné systémy-svodidlo | 7.30883 | 1 | no | ((-642745.584109535,-1062729.14392595,232.912744067133),(-642737.634631396,-1062728.08805258,233.796853666443)) | ByLayer | 4 | záchytné systémy-svodidlo | Barva_4 |  |  |  |  | P2 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | záchytné systémy | 798.82 | 802.18 | svodidlo | 9113A1 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: svodidlo; Stavební výrobek: ocelové svodidlo N2; Specifikace: TP 203; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 8
záchytné systémy-svodidlo | 169.204 | 1 | no | ((-642986.010159198,-1062728.29050001,232.813711880585),(-642812.974628161,-1062662.71546281,233.799916632288)) | ByLayer | 4 | záchytné systémy-svodidlo | Barva_4 |  |  |  |  | P2 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | záchytné systémy | 565 | 751.51 | svodidlo | 9113A1 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: svodidlo; Stavební výrobek: ocelové svodidlo N2; Specifikace: TP 203; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 186.51
vozovka_chodník-kryt z dlažebních dílců | 66.9954 | 1 | no | ((-642801.027218206,-1062728.32797374,232.987698658292),(-642794.021450479,-1062716.67973467,233.328383330534)) | ByLayer | 9 | vozovka_chodník-kryt z dlažebních dílců | Barva_9 | nerelevantni | D1.1.4 | žul. kostky velké spárováno MC | TP 192 | P2 | 191;191;191 | 4.64695 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 761.49 | 773.38 | kryt z dlažebních dílců | 58210 | I1+S1+E1+Z1+M3;2&6+F1 | 0.1
vozovka_chodník-ložní vrstva | 65.3259 | 1 | no | ((-642801.027218206,-1062728.32797374,232.887698658292),(-642794.021450479,-1062716.67973467,233.178383330534)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | beton C20/25nXF3 | nerelevantni | P2 | 128;128;128 | 3.09797 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 761.49 | 773.38 | ložní vrstva | 45131A | I1+S1+E1+Z1+M3;2&6+F1 | 0.1
zemní práce-aktivní zóna | 225.72 | 1 | no | ((-642687.653213985,-1062836.56810774,232.250927965645),(-642672.870388918,-1062819.57830344,233.071950738902)) | ByLayer | 16 | zemní práce-aktivní zóna | Barva_16 | vhodná, podmínečně vhodná | D1.1.4 | zemina | ČSN 73 6133 | P100 | 128;0;0 | 50.72 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 919.96 | 926.04 | aktivní zóna | 17180 | I1+S1+E1+Z1+M3+F1
zemní práce-výkop_odkop | 14.4196 | 1 | no | ((-642595.835387224,-1062896.33883129,231.925064102137),(-642583.416866781,-1062889.55865789,232.157073346608)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 0.333103 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1026.86 | 1040.88 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 0.180466 | 1 | no | ((-642831.315326283,-1062723.53946204,232.289124989254),(-642830.857682988,-1062723.03646484,232.327394389204)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 0.00104418 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 732.04 | 732.36 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
objekty na TV-uliční vpusť | 2.26199 | 2 | yes | ((-642791.682828908,-1062751.23783249,232.215),(-642790.975751212,-1062750.5307548,233.395)) | ByLayer | 4 | objekty na TV-uliční vpusť | Barva_4 |  |  |  |  | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | objekty na TV | 773.73 | 774.43 | uliční vpusť | 89712 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: uliční vpusť; Stavební výrobek: nerelevantni; Specifikace: mříž D400, bet. dílce DN450, přípojka DN150; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-podkladní a výplňové vrstvy | 1.605 | 2 | yes | ((-642791.859598332,-1062751.41460192,232.055),(-642790.798981789,-1062750.35398537,232.215)) | ByLayer | 8 | zemní práce-podkladní a výplňové vrstvy | Barva_8 |  |  |  |  | P100 | 128;128;128 | 0.09 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 773.55 | 774.61 | podkladní a výplňové vrstvy | 17511 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: vhodná nebo podmínečně vhodná; Třída těžitelnosti: 1; Další specifikace: ČSN 73 6133
objekty na TV-uliční vpusť | 2.26199 | 2 | yes | ((-642787.772707706,-1062754.25836123,232.24),(-642787.088303254,-1062753.57395677,233.42)) | ByLayer | 4 | objekty na TV-uliční vpusť | Barva_4 |  |  |  |  | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | objekty na TV | 777.4 | 778.1 | uliční vpusť | 89712 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: uliční vpusť; Stavební výrobek: nerelevantni; Specifikace: mříž D400, bet. dílce DN450, přípojka DN150; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-podkladní a výplňové vrstvy | 1.605 | 2 | yes | ((-642787.943808819,-1062754.42946234,232.08),(-642786.917202141,-1062753.40285566,232.24)) | ByLayer | 8 | zemní práce-podkladní a výplňové vrstvy | Barva_8 |  |  |  |  | P100 | 128;128;128 | 0.09 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 777.23 | 778.27 | podkladní a výplňové vrstvy | 17511 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: vhodná nebo podmínečně vhodná; Třída těžitelnosti: 1; Další specifikace: ČSN 73 6133
objekty na TV-uliční vpusť | 2.26199 | 2 | yes | ((-642783.21142365,-1062756.19767771,232.27),(-642782.588689446,-1062755.5749435,233.45)) | ByLayer | 4 | objekty na TV-uliční vpusť | Barva_4 |  |  |  |  | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | objekty na TV | 802 | 802.7 | uliční vpusť | 89712 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: uliční vpusť; Stavební výrobek: nerelevantni; Specifikace: mříž D400, bet. dílce DN450, přípojka DN150; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-podkladní a výplňové vrstvy | 1.605 | 2 | yes | ((-642783.367107201,-1062756.35336126,232.11),(-642782.433005895,-1062755.41925995,232.27)) | ByLayer | 8 | zemní práce-podkladní a výplňové vrstvy | Barva_8 |  |  |  |  | P100 | 128;128;128 | 0.09 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 801.82 | 802.88 | podkladní a výplňové vrstvy | 17511 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: vhodná nebo podmínečně vhodná; Třída těžitelnosti: 1; Další specifikace: ČSN 73 6133
objekty na TV-uliční vpusť | 2.26199 | 2 | yes | ((-642771.78200285,-1062761.75265963,232.16),(-642771.077987018,-1062761.04864379,233.34)) | ByLayer | 4 | objekty na TV-uliční vpusť | Barva_4 |  |  |  |  | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | objekty na TV | 810.54 | 811.07 | uliční vpusť | 89712 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: uliční vpusť; Stavební výrobek: nerelevantni; Specifikace: mříž D400, bet. dílce DN450, přípojka DN150; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-podkladní a výplňové vrstvy | 1.605 | 2 | yes | ((-642771.958006808,-1062761.92866358,232),(-642770.90198306,-1062760.87263984,232.16)) | ByLayer | 8 | zemní práce-podkladní a výplňové vrstvy | Barva_8 |  |  |  |  | P100 | 128;128;128 | 0.09 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 810.41 | 811.2 | podkladní a výplňové vrstvy | 17511 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: vhodná nebo podmínečně vhodná; Třída těžitelnosti: 1; Další specifikace: ČSN 73 6133
objekty na TV-uliční vpusť | 2.26199 | 2 | yes | ((-642819.661533666,-1062741.32700638,231.865),(-642819.035726119,-1062740.70119884,233.045)) | ByLayer | 4 | objekty na TV-uliční vpusť | Barva_4 |  |  |  |  | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | objekty na TV | 747.92 | 748.44 | uliční vpusť | 89712 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: uliční vpusť; Stavební výrobek: nerelevantni; Specifikace: mříž D400, bet. dílce DN450, přípojka DN200; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-podkladní a výplňové vrstvy | 1.605 | 2 | yes | ((-642819.817985553,-1062741.48345827,231.705),(-642818.879274232,-1062740.54474695,231.865)) | ByLayer | 8 | zemní práce-podkladní a výplňové vrstvy | Barva_8 |  |  |  |  | P100 | 128;128;128 | 0.09 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 747.79 | 748.57 | podkladní a výplňové vrstvy | 17511 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: vhodná nebo podmínečně vhodná; Třída těžitelnosti: 1; Další specifikace: ČSN 73 6133
objekty na TV-šachta | 7.79115 | 2 | yes | ((-642775.046412084,-1062763.75719443,232.053575123314),(-642773.728820658,-1062762.44021286,233.436646276027)) | ByLayer | 5 | objekty na TV-šachta | Barva_5 |  |  |  |  | P10 | 0;0;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | objekty na TV | 810.27 | 810.27 | šachta | 894145 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: šachta; Stavební výrobek: bet. dílce, kanalizační šachta DN1000, poklop B125; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.588 | 2 | yes | ((-642748.859725346,-1062772.6144153,234.550000000047),(-642748.644876743,-1062772.37742368,235.449999999953)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 834.92 | 834.94 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z4b; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.588 | 2 | yes | ((-642817.964532845,-1062741.58483985,234.15000000014),(-642817.873116792,-1062741.28880809,235.050000000047)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 749.61 | 749.64 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z4c; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.588 | 2 | yes | ((-642806.926428569,-1062736.78221473,233.750000000233),(-642806.62168184,-1062736.46942098,234.65000000014)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 759.39 | 759.41 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z4b; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.588 | 2 | yes | ((-642789.829406263,-1062716.76636159,234.350000000326),(-642789.625920906,-1062716.51996384,235.250000000233)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 778.06 | 778.28 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z4b; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.588 | 2 | yes | ((-642755.21769985,-1062735.09972615,234.050000000047),(-642754.897947359,-1062734.78061343,234.949999999953)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 798.78 | 799.06 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z4b; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.469657 | 2 | yes | ((-642784.500579917,-1062712.01541529,235.450526120141),(-642784.070654666,-1062710.98775467,235.650526120095)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 0.784 | 0.784 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IS5; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.469657 | 2 | yes | ((-642807.833332065,-1062728.49641158,234.757349141641),(-642807.782791972,-1062727.39628041,234.957349141594)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 763.71 | 764.34 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IS3a; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.469657 | 2 | yes | ((-642767.478977148,-1062767.86484826,235.790835151915),(-642766.920099635,-1062766.89750037,235.990835151868)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 804.64 | 805.19 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IS1c; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.469657 | 2 | yes | ((-642746.219957135,-1062739.79337945,234.703506884864),(-642745.916914796,-1062738.7254399,234.903506884817)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 806.88 | 812.16 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IS3a; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.332 | 2 | yes | ((-642555.839676817,-1062909.30721789,233.489633148433),(-642555.606093499,-1062908.84743812,233.78963314848)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1071.12 | 1071.18 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IS16d; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 1.268 | 2 | yes | ((-642696.30493146,-1062827.61418513,233.873030334373),(-642695.992915557,-1062827.19930257,235.073030334373)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 909.94 | 910 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IP18d; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.469657 | 2 | yes | ((-642767.478977148,-1062767.86484826,235.540835151915),(-642766.920099635,-1062766.89750037,235.740835151868)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 804.64 | 805.19 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IS3a; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
trubní vedení-potrubí | 1.27718 | 1 | no | ((-642791.579489656,-1062753.70112189,232.49),(-642791.377877483,-1062751.05878149,232.666399112968)) | ByLayer | 4 | trubní vedení-potrubí | Barva_4 | nerelevantni | D1.1.4 | PP SN 12 DN150 | nerelevantni | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 773.68 | 773.97 | potrubí | 87433 | I1+S3+E1+Z1+M1+F1 | CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 2.6
trubní vedení-podsyp | 3.10197 | 1 | no | ((-642791.679470522,-1062753.70307805,232.39),(-642791.277896617,-1062751.05682534,232.591399112968)) | ByLayer | 2 | trubní vedení-podsyp | Barva_2 | nerelevantni | D1.1.4 | ŠP | nerelevantni | P50 | 255;255;0 | 0.138519 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 773.58 | 774.07 | podsyp | 45157 | I1+S3+E1+Z1+M3+F1
trubní vedení-obsyp | 3.10197 | 1 | no | ((-642791.679470522,-1062753.70307805,232.565),(-642791.277896617,-1062751.05682534,232.766399112968)) | ByLayer | 40 | trubní vedení-obsyp | Barva_40 |  |  |  |  | P50 | 255;165;0 | 0.138519 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 773.58 | 774.07 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | 0.4 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: ŠP; Stavební výrobek: nerelevantni; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni
trubní vedení-potrubí | 0.851755 | 1 | no | ((-642787.632156404,-1062755.86853574,232.45),(-642787.448231939,-1062754.13022821,232.617357054108)) | ByLayer | 4 | trubní vedení-potrubí | Barva_4 | nerelevantni | D1.1.4 | PP SN 12 DN150 | nerelevantni | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 777.44 | 777.68 | potrubí | 87433 | I1+S3+E1+Z1+M1+F1 | CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 1.7
trubní vedení-podsyp | 2.07544 | 1 | no | ((-642787.732137269,-1062755.8704919,232.35),(-642787.348251074,-1062754.12827205,232.542357054108)) | ByLayer | 2 | trubní vedení-podsyp | Barva_2 | nerelevantni | D1.1.4 | ŠP | nerelevantni | P50 | 255;255;0 | 0.0910741 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 777.34 | 777.78 | podsyp | 45157 | I1+S3+E1+Z1+M3+F1
trubní vedení-obsyp | 2.07544 | 1 | no | ((-642787.732137269,-1062755.8704919,232.525),(-642787.348251074,-1062754.12827205,232.717357054108)) | ByLayer | 40 | trubní vedení-obsyp | Barva_40 |  |  |  |  | P50 | 255;165;0 | 0.0910741 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 777.34 | 777.78 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | 0.4 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: ŠP; Stavební výrobek: nerelevantni; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni
trubní vedení-potrubí | 1.107 | 1 | no | ((-642783.04701631,-1062758.40334384,232.39),(-642782.852479539,-1062756.12263291,232.562782126196)) | ByLayer | 4 | trubní vedení-potrubí | Barva_4 | nerelevantni | D1.1.4 | PP SN 12 DN150 | nerelevantni | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 802.48 | 804.52 | potrubí | 87433 | I1+S3+E1+Z1+M1+F1 | CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 2.3
trubní vedení-podsyp | 2.69134 | 1 | no | ((-642783.146997175,-1062758.4053,232.29),(-642782.752498674,-1062756.12067675,232.487782126196)) | ByLayer | 2 | trubní vedení-podsyp | Barva_2 | nerelevantni | D1.1.4 | ŠP | nerelevantni | P50 | 255;255;0 | 0.11954 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 802.43 | 804.57 | podsyp | 45157 | I1+S3+E1+Z1+M3+F1
trubní vedení-obsyp | 2.69134 | 1 | no | ((-642783.146997175,-1062758.4053,232.465),(-642782.752498674,-1062756.12067675,232.662782126196)) | ByLayer | 40 | trubní vedení-obsyp | Barva_40 |  |  |  |  | P50 | 255;165;0 | 0.11954 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 802.43 | 804.57 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | 0.4 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: ŠP; Stavební výrobek: nerelevantni; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni
trubní vedení-potrubí | 1.34403 | 1 | no | ((-642774.183893153,-1062762.73858649,232.3),(-642771.560473245,-1062761.52400623,232.477820068524)) | ByLayer | 4 | trubní vedení-potrubí | Barva_4 | nerelevantni | D1.1.4 | PP SN 12 DN150 | nerelevantni | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 809.61 | 810.88 | potrubí | 87433 | I1+S3+E1+Z1+M1+F1 | CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 2.8
trubní vedení-podsyp | 3.26328 | 1 | no | ((-642774.222579606,-1062762.83080015,232.2),(-642771.521786792,-1062761.43179258,232.402820068524)) | ByLayer | 2 | trubní vedení-podsyp | Barva_2 | nerelevantni | D1.1.4 | ŠP | nerelevantni | P50 | 255;255;0 | 0.145975 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 809.51 | 810.98 | podsyp | 45157 | I1+S3+E1+Z1+M3+F1
trubní vedení-obsyp | 3.26328 | 1 | no | ((-642774.222579606,-1062762.83080015,232.375),(-642771.521786792,-1062761.43179258,232.577820068524)) | ByLayer | 40 | trubní vedení-obsyp | Barva_40 |  |  |  |  | P50 | 255;165;0 | 0.145975 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 809.51 | 810.98 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | 0.4 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: ŠP; Stavební výrobek: nerelevantni; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni
trubní vedení-potrubí | 14.9965 | 1 | no | ((-642791.513233568,-1062762.98541612,232.30098082428),(-642774.755323375,-1062753.59019971,232.74098082428)) | ByLayer | 4 | trubní vedení-potrubí | Barva_4 | nerelevantni | D1.1.4 | PP SN 12 DN250 | nerelevantni | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 773.68 | 809.36 | potrubí | 87444 | I1+S3+E1+Z1+M1+F1 | CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 19
trubní vedení-podsyp | 28.5038 | 1 | no | ((-642791.561529917,-1062763.07298017,232.20098082428),(-642774.707027026,-1062753.50263566,232.61598082428)) | ByLayer | 2 | trubní vedení-podsyp | Barva_2 | nerelevantni | D1.1.4 | ŠP | nerelevantni | P50 | 255;255;0 | 1.46041 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 773.63 | 809.39 | podsyp | 45157 | I1+S3+E1+Z1+M3+F1
trubní vedení-obsyp | 28.5038 | 1 | no | ((-642791.561529917,-1062763.07298017,232.42598082428),(-642774.707027026,-1062753.50263566,232.84098082428)) | ByLayer | 40 | trubní vedení-obsyp | Barva_40 |  |  |  |  | P50 | 255;165;0 | 1.46041 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 773.63 | 809.39 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | 0.4 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: ŠP; Stavební výrobek: nerelevantni; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni
trubní vedení-potrubí | 7.12347 | 1 | no | ((-642779.072141804,-1062771.62237205,232.199272050678),(-642774.53621657,-1062763.50483166,232.54098082428)) | ByLayer | 4 | trubní vedení-potrubí | Barva_4 | nerelevantni | D1.1.4 | PP SN 12 DN250 | nerelevantni | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 809.8 | 812.27 | potrubí | 87444 | I1+S3+E1+Z1+M1+F1 | CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 9.2
trubní vedení-podsyp | 13.7695 | 1 | no | ((-642779.248886103,-1062771.74692726,232.099000000001),(-642774.448432371,-1062763.45693663,232.41598082428)) | ByLayer | 2 | trubní vedení-podsyp | Barva_2 | nerelevantni | D1.1.4 | ŠP | nerelevantni | P50 | 255;255;0 | 0.701557 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 809.71 | 812.43 | podsyp | 45157 | I1+S3+E1+Z1+M3+F1
trubní vedení-obsyp | 13.0252 | 1 | no | ((-642779.078127361,-1062771.44906878,232.327393076318),(-642774.448432371,-1062763.45693663,232.640980824279)) | ByLayer | 40 | trubní vedení-obsyp | Barva_40 |  |  |  |  | P50 | 255;165;0 | 0.654341 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 809.71 | 812.34 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | 0.4 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: ŠP; Stavební výrobek: nerelevantni; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni
trubní vedení-potrubí | 3.88763 | 1 | no | ((-642822.928102631,-1062748.7995952,232.097021313916),(-642819.354662282,-1062741.22147746,232.329921313917)) | ByLayer | 4 | trubní vedení-potrubí | Barva_4 | nerelevantni | D1.1.4 | PP SN 12 DN200 | nerelevantni | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 746.58 | 748.23 | potrubí | 87434 | I1+S3+E1+Z1+M1+F1 | CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 8
trubní vedení-podsyp | 9.48754 | 1 | no | ((-642823.049621327,-1062748.85585718,231.997021313916),(-642819.263832374,-1062741.17964532,232.254921313917)) | ByLayer | 2 | trubní vedení-podsyp | Barva_2 | nerelevantni | D1.1.4 | ŠP | nerelevantni | P50 | 255;255;0 | 0.433921 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 746.46 | 748.33 | podsyp | 45157 | I1+S3+E1+Z1+M3+F1
