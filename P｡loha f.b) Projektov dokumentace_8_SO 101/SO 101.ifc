Properties of the parts of a building model (IFC4X3_ADD2), part 17 of 21

# IfcBuiltElement (2093)
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | Linetype | ColorIndex | Layer | PlotStyleName | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | Skupina elementů | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Tloušťka
trubní vedení-obsyp | 9.16162 | 1 | no | ((-642822.982438226,-1062748.70983709,232.173627330281),(-642819.263832374,-1062741.17964532,232.429921313917)) | ByLayer | 40 | trubní vedení-obsyp | Barva_40 |  |  |  |  | P50 | 255;165;0 | 0.413498 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 746.49 | 748.33 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | 0.4 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: ŠP; Stavební výrobek: nerelevantni; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni
záchytné systémy-svodidlo | 203.473 | 1 | no | ((-642754.072179438,-1062887.40670512,232.71901894042),(-642574.925999392,-1062755.98038717,234.411403447312)) | ByLayer | 4 | záchytné systémy-svodidlo | Barva_4 |  |  |  |  | P2 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | záchytné systémy | 820 | 1044 | svodidlo | 9113A1 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: svodidlo; Stavební výrobek: ocelové svodidlo N2; Specifikace: TP 203; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 223
zemní práce-výkop_odkop | 0.000318554 | 1 | no | ((-642832.514237775,-1062727.44941842,232.427099733578),(-642832.493116083,-1062727.43355403,232.427597536497)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 6.48503e-09 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 732.04 | 732.06 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 0.911217 | 1 | no | ((-642831.871903689,-1062725.35460301,232.306158916294),(-642831.174410373,-1062723.57931561,232.361865046986)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 0.00155521 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 732.04 | 732.55 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 42.3707 | 1 | no | ((-642827.164764773,-1062728.49199019,232.305097911387),(-642813.477681511,-1062724.1235983,232.436)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 0.73896 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 737.06 | 750.57 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 2005.09 | 1 | no | ((-642602.651225451,-1062924.27523538,231.991625173159),(-642523.079520921,-1062868.64677767,233.663522811586)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 406.917 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1010.75 | 1100 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 0.302804 | 1 | no | ((-642669.918919815,-1062817.6404112,229.990848054313),(-642668.902342276,-1062816.72018859,230.085981365338)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 0.00278838 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 924.7 | 926.04 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 0.655522 | 1 | no | ((-642668.956978197,-1062820.00083018,230.037044319314),(-642665.971949545,-1062817.56514721,230.174860512001)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 0.00469886 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 926.04 | 929.89 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 1105.16 | 1 | no | ((-642838.46037331,-1062757.38044323,231.623548797075),(-642793.616263773,-1062728.07967186,232.804)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 94.9187 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 731.23 | 772.46 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 1.02945 | 1 | no | ((-642720.943758275,-1062819.8958587,229.625302872351),(-642718.418024414,-1062818.27520147,229.812026267449)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 0.017834 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 885.15 | 888.07 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 0.475755 | 1 | no | ((-642783.128158328,-1062772.45056727,231.700849870145),(-642779.300672843,-1062770.2528694,231.746098757089)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 0.00205404 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 780.85 | 812.58 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 0.649138 | 1 | no | ((-642724.55824721,-1062816.88904505,229.636262590144),(-642722.873305429,-1062815.45196518,229.773929945004)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 0.00874759 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 880.65 | 882.82 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-násyp | 0.428675 | 1 | no | ((-642825.647334576,-1062748.16167035,231.25),(-642824.972991325,-1062748.01462741,231.854735835627)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 0.00582157 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 743.93 | 744.57 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-výkop_odkop | 2200.25 | 1 | no | ((-642621.717006944,-1062924.84025856,231.628526123628),(-642522.984897411,-1062854.86794471,233.670686980197)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 527.779 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 986.81 | 1100 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 0.302804 | 1 | no | ((-642669.918919815,-1062817.6404112,229.990848054326),(-642668.902342276,-1062816.72018858,230.085981365338)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 0.00278838 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 924.7 | 926.04 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 0.655522 | 1 | no | ((-642668.956978197,-1062820.00083018,230.037044319314),(-642665.971949545,-1062817.56514721,230.174860512)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 0.00469886 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 926.04 | 929.89 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-aktivní zóna | 5218.81 | 1 | no | ((-642682.697042833,-1062922.51579097,231.491625173159),(-642524.645554484,-1062823.03135022,233.047438629822)) | ByLayer | 16 | zemní práce-aktivní zóna | Barva_16 | vhodná, podmínečně vhodná | D1.1.4 | zemina | ČSN 73 6133 | P100 | 128;0;0 | 1256.95 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 926.04 | 1100 | aktivní zóna | 17180 | I1+S1+E1+Z1+M3+F1
zemní práce-aktivní zóna | 15545.3 | 1 | no | ((-642990.235495677,-1062832.9471227,231.413416375383),(-642677.813071675,-1062661.10817313,233.140653447312)) | ByLayer | 16 | zemní práce-aktivní zóna | Barva_16 | vhodná, podmínečně vhodná | D1.1.4 | zemina | ČSN 73 6133 | P100 | 128;0;0 | 3774.49 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 565 | 919.96 | aktivní zóna | 17180 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-ložní vrstva | 71.8759 | 1 | no | ((-642758.756393828,-1062750.93438016,232.85),(-642741.587751918,-1062736.44183087,233.337563658429)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | beton C20/25nXF3 | nerelevantni | P2 | 128;128;128 | 3.33802 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 803.4 | 815.82 | ložní vrstva | 45131A | I1+S1+E1+Z1+M3;2&6+F1 | 0.1
vozovka_chodník-kryt z dlažebních dílců | 74.4213 | 1 | no | ((-642758.756393828,-1062750.93438016,232.95),(-642741.587751918,-1062736.44183087,233.487563658429)) | ByLayer | 9 | vozovka_chodník-kryt z dlažebních dílců | Barva_9 | nerelevantni | D1.1.4 | žul. kostky velké spárováno MC | TP 192 | P2 | 191;191;191 | 5.00703 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 803.4 | 815.82 | kryt z dlažebních dílců | 58210 | I1+S1+E1+Z1+M3;2&6+F1 | 0.1
vozovka_chodník-spodní podkladní vrstva | 45.2121 | 1 | no | ((-642837.063546201,-1062742.29391898,232.369625618723),(-642818.010205082,-1062734.37578278,232.698636258354)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 4.3069 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 729.77 | 749.31 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-horní podkladní vrstva | 43.0673 | 1 | no | ((-642837.063090922,-1062742.29241536,232.619630404061),(-642818.000304865,-1062734.37427917,232.898670474365)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 3.44551 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 729.77 | 749.32 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 37.375 | 1 | no | ((-642760.972924402,-1062783.84787747,233.183109145334),(-642744.187119077,-1062771.35174982,233.420014897541)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.20206 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 825.98 | 845.8 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 36.9448 | 1 | no | ((-642760.972924402,-1062783.84787747,233.253109145334),(-642744.187119077,-1062771.35174982,233.480014897541)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.03034 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 825.98 | 845.8 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-obrusná vrstva | 36.0845 | 1 | no | ((-642760.972924402,-1062783.84787747,233.313109145334),(-642744.187119077,-1062771.35174982,233.520014897541)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.686894 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 825.98 | 845.8 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-spodní podkladní vrstva | 65.5209 | 1 | no | ((-642807.514655915,-1062739.43698102,232.697745197018),(-642797.586589808,-1062735.54524551,233.074960504581)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 8.20347 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 758.67 | 768.86 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 281.477 | 1 | no | ((-642770.460048447,-1062773.86161248,232.909454939338),(-642747.043391603,-1062753.32462571,233.373635866844)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 36.9141 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 809.05 | 836.47 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 27.8614 | 1 | no | ((-642791.103236871,-1062719.787648,232.807491508913),(-642784.579410762,-1062715.54348111,233.10903360942)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 3.07139 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 776.87 | 783.23 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 29.8532 | 1 | no | ((-642791.128089686,-1062719.78687225,233.068773575695),(-642784.573418903,-1062715.39278664,233.359066110232)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 3.21346 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 776.85 | 783.24 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-ložní vrstva | 26.3716 | 1 | no | ((-642791.127254709,-1062719.787648,233.318741074883),(-642784.572583926,-1062715.39356239,233.39903360942)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | lože HDK | TP 192 | P2 | 128;128;128 | 0.514154 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 776.85 | 783.24 | ložní vrstva | nerelevantni | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-kryt z dlažebních dílců | 27.3663 | 1 | no | ((-642791.127254709,-1062719.787648,233.358741074883),(-642784.572583926,-1062715.39356239,233.49903360942)) | ByLayer | 9 | vozovka_chodník-kryt z dlažebních dílců | Barva_9 | nerelevantni | D1.1.4 | žul. kostka malá do lože z HDK | TP 192 | P2 | 191;191;191 | 1.28538 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 776.85 | 783.24 | kryt z dlažebních dílců | 58221 | I1+S1+E1+Z1+M3;2&6+F1 | 0.1
vozovka_chodník-spodní podkladní vrstva | 280.753 | 1 | no | ((-642770.460048447,-1062774.01158543,233.192829252987),(-642746.893422556,-1062753.32462571,233.623635866844)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 33.1037 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 809.14 | 836.62 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 64.7506 | 1 | no | ((-642807.514655915,-1062739.43698102,232.981052345314),(-642797.586589808,-1062735.54524551,233.324960504581)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 7.3237 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 758.67 | 768.86 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-ložní vrstva | 267.402 | 1 | no | ((-642770.460048447,-1062774.01158543,233.442829252987),(-642746.893422556,-1062753.32462571,233.663635866844)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | lože HDK | TP 192 | P2 | 128;128;128 | 5.29659 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 809.14 | 836.62 | ložní vrstva | nerelevantni | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 59.578 | 1 | no | ((-642807.514655915,-1062739.43698102,233.231052345314),(-642797.586589808,-1062735.54524551,233.364960504581)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | lože HDK | TP 192 | P2 | 128;128;128 | 1.17179 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 758.67 | 768.86 | ložní vrstva | nerelevantni | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-kryt z dlažebních dílců | 269.945 | 1 | no | ((-642770.460048447,-1062774.01158543,233.482829252987),(-642746.893422556,-1062753.32462571,233.743635866844)) | ByLayer | 9 | vozovka_chodník-kryt z dlažebních dílců | Barva_9 | nerelevantni | D1.1.4 | bet. dlažba tl. 80 mm v loži HDK | TP 192 | P2 | 191;191;191 | 10.5932 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 809.14 | 836.62 | kryt z dlažebních dílců | 582612 | I1+S1+E1+Z1+M3;2&6+F1 | 0.08
vozovka_chodník-kryt z dlažebních dílců | 60.5633 | 1 | no | ((-642807.514655915,-1062739.43698102,233.271052345314),(-642797.586589808,-1062735.54524551,233.444960504581)) | ByLayer | 9 | vozovka_chodník-kryt z dlažebních dílců | Barva_9 | nerelevantni | D1.1.4 | bet. dlažba tl. 80 mm v loži HDK | TP 192 | P2 | 191;191;191 | 2.34359 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 758.67 | 768.86 | kryt z dlažebních dílců | 582612 | I1+S1+E1+Z1+M3;2&6+F1 | 0.08
vozovka_chodník-spodní podkladní vrstva | 217.99 | 1 | no | ((-642802.554307227,-1062726.30426119,232.682999721963),(-642787.064598064,-1062712.07660136,233.073625062634)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 20.8305 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 759.73 | 780.63 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 2.7528 | 1 | no | ((-642786.428795891,-1062719.11244297,233.071809424402),(-642782.997340219,-1062717.22416769,233.23404975312)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.110058 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 781.28 | 784.81 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 1.9829 | 1 | no | ((-642786.428795891,-1062719.11244297,233.221809424402),(-642782.997340219,-1062717.22416769,233.29404975312)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0440234 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 781.28 | 784.81 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 1.89736 | 1 | no | ((-642786.428795891,-1062719.11244297,233.281809424402),(-642782.997340219,-1062717.22416769,233.34404975312)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0366861 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 781.28 | 784.81 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-obrusná vrstva | 1.81181 | 1 | no | ((-642786.428795891,-1062719.11244297,233.331809424402),(-642782.997340219,-1062717.22416769,233.38404975312)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0293489 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 781.28 | 784.81 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
zemní práce-zemní krajnice a dosypávky | 324.092 | 1 | no | ((-642674.287645968,-1062867.75294854,232.616858401064),(-642608.770202392,-1062823.35957363,233.396210260873)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 27.3074 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 926.04 | 1003.81 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 79.2364 | 1 | no | ((-642695.03899284,-1062821.41845751,233.032702133916),(-642678.05349858,-1062807.94636511,233.474829983584)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 6.48271 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 900 | 919.96 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 316.601 | 1 | no | ((-642674.394116121,-1062867.9080833,232.865587351916),(-642608.882881445,-1062823.53593833,233.561188629824)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 19.0586 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1003.81 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 73.4192 | 1 | no | ((-642695.149570752,-1062821.56442036,233.294702774491),(-642678.233736551,-1062808.22063189,233.639808352801)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 4.57318 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-spodní podkladní vrstva | 428.553 | 1 | no | ((-642674.394116097,-1062867.9080833,232.454623282341),(-642608.560501125,-1062823.03135022,233.191188629823)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 35.3217 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1003.81 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 106.024 | 1 | no | ((-642695.149570752,-1062821.56442037,232.870467015233),(-642677.813071675,-1062807.62501469,233.269808352801)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 8.71961 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-horní podkladní vrstva | 113.069 | 1 | no | ((-642674.394116097,-1062867.9080833,232.788742288445),(-642609.592497215,-1062824.6466255,233.391188629824)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 6.84036 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1003.81 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 29.1551 | 1 | no | ((-642695.149570752,-1062821.56442023,233.200756632069),(-642678.920609855,-1062809.1386948,233.469808352801)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 1.75586 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 37.6483 | 1 | no | ((-642674.394116097,-1062867.9080833,232.999034496237),(-642609.805352635,-1062824.97978577,233.461188629824)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.912221 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1003.81 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 9.68147 | 1 | no | ((-642695.149570752,-1062821.56442023,233.411048840169),(-642679.164653062,-1062809.46487871,233.539808352801)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.234161 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 23.1458 | 1 | no | ((-642674.394116098,-1062867.9080833,233.071170572187),(-642609.849529292,-1062825.04893086,233.521188629823)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.396858 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1003.81 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 5.94893 | 1 | no | ((-642695.149570752,-1062821.56442024,233.483184915951),(-642679.215302528,-1062809.53257591,233.599808352801)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.101871 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-obrusná vrstva | 8.1715 | 1 | no | ((-642674.394116121,-1062867.9080833,233.133180065858),(-642609.891088074,-1062825.11397846,233.561188629823)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0313519 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1003.81 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 2.09816 | 1 | no | ((-642695.149570752,-1062821.56442036,233.545194409789),(-642679.262950538,-1062809.59626142,233.639808352801)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00804804 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
zemní práce-rozprostření ornice (ohumusovani) | 901.99 | 1 | no | ((-642673.533372225,-1062866.65375923,230.280216615945),(-642607.035446247,-1062817.91770842,233.29347891422)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 33.9287 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 926.04 | 1003.81 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 338.018 | 1 | no | ((-642694.265379381,-1062820.39728858,230.18608178909),(-642673.834904445,-1062802.38751589,233.440692880286)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 24.1332 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 900 | 919.96 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-zemní krajnice a dosypávky | 366.694 | 1 | no | ((-642682.558581842,-1062888.37603995,232.515075290731),(-642594.593181791,-1062834.98808075,233.308710260735)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 30.0223 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 926.04 | 1026.77 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 74.0663 | 1 | no | ((-642703.629034219,-1062832.75730286,232.932578431764),(-642686.495828522,-1062819.2636004,233.387329983583)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 6.56721 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 900 | 919.96 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 354.781 | 1 | no | ((-642682.475451506,-1062888.09636117,232.805424954209),(-642594.503376282,-1062834.84141227,233.473688649757)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 21.2535 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1026.77 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 74.5144 | 1 | no | ((-642703.542696586,-1062832.64333728,233.207202774528),(-642686.388392409,-1062819.12000316,233.552308352799)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 4.64181 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-spodní podkladní vrstva | 487.193 | 1 | no | ((-642682.697042833,-1062888.72833482,232.352840172007),(-642594.503376282,-1062834.84141227,233.103688629964)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 42.1665 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1026.77 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 94.9647 | 1 | no | ((-642703.838701368,-1062832.9471227,232.775440074578),(-642686.388392409,-1062819.12000316,233.182308352799)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 8.10663 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-horní podkladní vrstva | 148.257 | 1 | no | ((-642681.794754043,-1062887.55567012,232.668579890745),(-642594.503376282,-1062834.84141227,233.303688629824)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 8.97009 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1026.77 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 29.5517 | 1 | no | ((-642702.835736762,-1062831.71015107,233.113256632226),(-642686.388392409,-1062819.12000316,233.382308352799)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 1.77976 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 49.3587 | 1 | no | ((-642681.552905086,-1062887.19807632,232.878872098537),(-642594.503376282,-1062834.84141227,233.373688629822)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.19584 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1026.77 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 9.80987 | 1 | no | ((-642702.584556898,-1062831.37859392,233.323548840039),(-642686.388392409,-1062819.12000316,233.452308352799)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.237267 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 30.3466 | 1 | no | ((-642681.502711022,-1062887.12386022,232.951008174486),(-642594.503376282,-1062834.84141227,233.433688729455)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.520178 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1026.77 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 6.02733 | 1 | no | ((-642702.532426269,-1062831.30978155,233.39568491576),(-642686.388392409,-1062819.12000316,233.512308352799)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.103207 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-obrusná vrstva | 10.7167 | 1 | no | ((-642681.45549142,-1062887.05404211,233.013017668157),(-642594.503376282,-1062834.84141227,233.473688649757)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0411054 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1026.77 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 2.12567 | 1 | no | ((-642702.483384863,-1062831.24504694,233.457694034786),(-642686.388392409,-1062819.12000316,233.552308352799)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00815569 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
zemní práce-rozprostření ornice (ohumusovani) | 1431.27 | 1 | no | ((-642687.323812104,-1062889.85818386,229.254589096604),(-642594.857857133,-1062836.01418716,233.20727295139)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 98.3313 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 926.04 | 1026.77 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 370.614 | 1 | no | ((-642708.300210479,-1062839.30881639,229.528021454666),(-642687.247461662,-1062820.26822019,233.285892674224)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 26.8819 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 900 | 919.96 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 2070.6 | 1 | no | ((-642681.443593568,-1062920.76389724,232.049978826331),(-642527.337484443,-1062828.56969645,233.29743862998)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 261.711 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1100 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 325.837 | 1 | no | ((-642702.471027973,-1062831.22873586,232.839450738774),(-642681.794298283,-1062812.97961681,233.376058352796)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 41.8567 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 1568.73 | 1 | no | ((-642676.890806035,-1062916.93609144,232.049978826346),(-642525.490756849,-1062825.13036841,233.297438629951)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 192.266 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1100 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 181.959 | 1 | no | ((-642697.742586851,-1062824.98719869,232.944450738555),(-642679.274956343,-1062809.61230816,233.376058352796)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 22.0609 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-horní podkladní vrstva | 2047.26 | 1 | no | ((-642681.443593568,-1062920.76389724,232.321228826331),(-642527.337484443,-1062828.56969645,233.49743862998)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 197.442 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1100 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 321.955 | 1 | no | ((-642702.471027973,-1062831.22873586,233.128200738773),(-642681.794298283,-1062812.97961681,233.576058352796)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 31.0738 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 1547.08 | 1 | no | ((-642676.890806035,-1062916.93609144,232.321228826344),(-642525.490756849,-1062825.13036841,233.497438629951)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 147.546 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1100 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 179.018 | 1 | no | ((-642697.742586851,-1062824.98719869,233.215700738555),(-642679.274956343,-1062809.61230816,233.576058352796)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 16.9298 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 2000.33 | 1 | no | ((-642681.443593568,-1062920.76389724,232.521228826331),(-642527.337484443,-1062828.56969645,233.56743862998)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 69.1045 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1100 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 314.728 | 1 | no | ((-642702.471027973,-1062831.22873586,233.328200738773),(-642681.794298283,-1062812.97961681,233.646058352796)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 10.8758 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 1500.84 | 1 | no | ((-642676.890806035,-1062916.93609144,232.521228826344),(-642525.490756849,-1062825.13036841,233.567438629951)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 51.6413 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1100 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 172.735 | 1 | no | ((-642697.742586851,-1062824.98719869,233.415700738555),(-642679.274956343,-1062809.61230816,233.646058352796)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 5.92543 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 1996.72 | 1 | no | ((-642681.443593568,-1062920.76389724,232.591228826331),(-642527.337484443,-1062828.56969645,233.62743862998)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 59.2325 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1100 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 314.172 | 1 | no | ((-642702.471027973,-1062831.22873586,233.398200738773),(-642681.794298283,-1062812.97961681,233.706058352796)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 9.32213 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 1497.28 | 1 | no | ((-642676.890806035,-1062916.93609144,232.591228826344),(-642525.490756849,-1062825.13036841,233.627438629951)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 44.2639 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1100 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 172.252 | 1 | no | ((-642697.742586851,-1062824.98719869,233.485700738555),(-642679.274956343,-1062809.61230816,233.706058352796)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 5.07894 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-obrusná vrstva | 1989.5 | 1 | no | ((-642681.443593568,-1062920.76389724,232.651228826331),(-642527.337484443,-1062828.56969645,233.66743862998)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 39.4883 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1100 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 313.06 | 1 | no | ((-642702.471027973,-1062831.22873586,233.458200738773),(-642681.794298283,-1062812.97961681,233.746058352796)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 6.21475 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 1490.17 | 1 | no | ((-642676.890806035,-1062916.93609144,232.651228826344),(-642525.490756849,-1062825.13036841,233.667438629951)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 29.5093 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 926.04 | 1100 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 171.285 | 1 | no | ((-642697.742586851,-1062824.98719869,233.545700738555),(-642679.274956343,-1062809.61230816,233.746058352796)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 3.38596 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 900 | 919.96 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
zemní práce-rozprostření ornice (ohumusovani) | 0.0006 | 2 | yes | ((-642799.76726468,-1062704.5891939,232.789748376034),(-642799.75726468,-1062704.5791939,232.799748376034)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 0.000001 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 760.37 | 760.38 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 0.0006 | 2 | yes | ((-642800.414488453,-1062707.45343498,233.112873978557),(-642800.404488453,-1062707.44343498,233.122873978557)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 0.000001 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 760.25 | 760.26 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 0.0006 | 2 | yes | ((-642800.422117188,-1062707.48719538,232.965163671551),(-642800.412117188,-1062707.47719538,232.975163671551)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.000001 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 760.24 | 760.26 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
propustky-zpevnění dlažbou | 9.52723 | 1 | no | ((-642823.5995684,-1062772.13739794,231.661812069687),(-642777.949926036,-1062747.5762972,232.677062414476)) | ByLayer | 8 | propustky-zpevnění dlažbou | Barva_8 | nerelevantni | D1.1.4 | lomový kámen, spárováno MC | nerelevantni | P50 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 746.05 | 812.85 | zpevnění dlažbou | 465512 | I1+S1+E1+Z1+M2+F1 | CZ_M2 - Způsob stanovení plochy: 3D plocha TIN povrchu; Plocha: 3.69798
propustky-lože | 8.1277 | 1 | no | ((-642823.5995684,-1062772.13739794,231.561812069687),(-642777.949926036,-1062747.5762972,232.477062414476)) | ByLayer | 16 | propustky-lože | Barva_16 | nerelevantni | D1.1.4 | beton | nerelevantni | P50 | 128;0;0 | 0.316008 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 746.05 | 812.85 | lože | 45131A | I1+S1;4+E1+Z1+M3+F1 | CZ_S4 - Specifikace: nerelevantni; Beton: C20/25nXF3; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D1.1.4; Návrhová životnost: 25 let
trasa-průjezdní a průchozí prostor | 0.06 | 2 | yes | ((-642988.037894803,-1062667.14884605,232.73),(-642987.937894803,-1062667.04884605,232.83)) | ByLayer | 9 | trasa-průjezdní a průchozí prostor | Barva_9 |  |  |  |  | P2 | 191;191;191 | CZ_I3 - Fáze projektu: PDPS; Označení položky: nerelevantni; Název (trasy): Silnice II/322; Staničení od: 564.93; Staničení do: 565.07; Označení elementu: průjezdní a průchozí prostor; Označení průjezdného profilu: nerelevantni; Klasifikační systém: nerelevantni; Označení šablony vlastností: I3+E1+Z1+F1
dopravní značení-svislé dopravní značení | 0.304459 | 2 | yes | ((-642842.241010962,-1062719.85914012,232.6),(-642842.162799552,-1062719.78092871,233.8)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 720.25 | 720.25 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642807.906985041,-1062728.0489152,232.606823021546),(-642807.804535455,-1062727.94646562,234.957349141594)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 764.05 | 764.05 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642784.396277008,-1062711.57601068,233.300000000047),(-642784.303440364,-1062711.48317404,235.650526120095)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 0.784 | 0.784 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642746.082794765,-1062739.24734246,232.552980764769),(-642745.984981423,-1062739.14952912,234.903506884817)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 811.62 | 811.62 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.62388 | 2 | yes | ((-642767.17128748,-1062767.40092915,233.39030903182),(-642767.09307607,-1062767.32271774,235.89030903182)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 804.95 | 804.95 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642696.148445419,-1062827.47490973,232.722504214324),(-642696.07023401,-1062827.39669832,235.073030334373)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 910.03 | 910.03 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.304459 | 2 | yes | ((-642555.717681971,-1062909.1376019,232.58963314848),(-642555.639470561,-1062909.05939049,233.78963314848)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1071.21 | 1071.21 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642857.485500825,-1062731.69203032,232.74),(-642857.407289415,-1062731.61381891,235.090526120048)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 710.26 | 710.26 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642817.911807534,-1062741.48801604,233.2),(-642817.833596124,-1062741.40980463,235.550526120048)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 749.71 | 749.71 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642806.766607606,-1062736.67522891,232.8),(-642806.688396196,-1062736.5970175,235.150526120048)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 759.49 | 759.49 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.746734 | 2 | yes | ((-642802.551237819,-1062744.83640431,233.3),(-642802.47302641,-1062744.7581929,236.3)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 765.04 | 765.04 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.746734 | 2 | yes | ((-642802.935620118,-1062717.91050503,233),(-642802.857408708,-1062717.83229362,236)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 759.74 | 759.74 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642788.930584104,-1062737.79176891,233),(-642788.852372694,-1062737.7135575,235.350526120048)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 777.51 | 777.51 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
