Properties of the parts of a building model (IFC4X3_ADD2), part 13 of 21

# IfcBuiltElement (2093)
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | Linetype | ColorIndex | Layer | PlotStyleName | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | Skupina elementů | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Tloušťka
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642286.2732237,-1063038.58574509,231.29701333654),(-642286.1732237,-1063038.48574509,232.04701333654)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1370.05 | 1370.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642241.239668463,-1063060.31217293,231.297624705501),(-642241.139668463,-1063060.21217293,232.047624705501)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1420.04 | 1420.04 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642196.053233603,-1063081.8276903,231.549628089719),(-642195.953233602,-1063081.7276903,232.299628089719)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1470.05 | 1470.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642150.758706092,-1063103.02416122,231.801631473946),(-642150.658706091,-1063102.92416122,232.551631473946)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1520.05 | 1520.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642105.468509547,-1063124.20901659,232.053634858165),(-642105.368509547,-1063124.10901659,232.803634858165)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1570.05 | 1570.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642060.178313003,-1063145.39387196,232.30563824239),(-642060.078313003,-1063145.29387196,233.05563824239)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1620.05 | 1620.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642014.888116459,-1063166.57872733,232.542581525096),(-642014.788116459,-1063166.47872733,233.292581525096)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1670.05 | 1670.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641969.597919915,-1063187.7635827,232.702550955525),(-641969.497919915,-1063187.6635827,233.452550955525)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1720.05 | 1720.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641924.307723371,-1063208.94843807,232.778853155272),(-641924.207723371,-1063208.84843807,233.528853155272)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1770.05 | 1770.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641879.017526827,-1063230.13329343,232.771488124313),(-641878.917526827,-1063230.03329343,233.521488124313)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1820.05 | 1820.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641833.727330283,-1063251.3181488,232.680455862644),(-641833.627330283,-1063251.2181488,233.430455862644)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1870.05 | 1870.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641788.437133739,-1063272.50300417,232.505756370277),(-641788.337133739,-1063272.40300417,233.255756370277)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1920.05 | 1920.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641743.146937195,-1063293.68785954,232.262449748738),(-641743.046937194,-1063293.58785954,233.012449748738)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1970.05 | 1970.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641697.85674065,-1063314.87271491,232.012449748733),(-641697.75674065,-1063314.77271491,232.762449748733)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2020.05 | 2020.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641652.566544106,-1063336.05757028,231.762588804793),(-641652.466544106,-1063335.95757028,232.512588804793)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2070.05 | 2070.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641607.276347562,-1063357.24242565,231.606451636198),(-641607.176347562,-1063357.14242565,232.356451636198)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2120.05 | 2120.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641561.986151018,-1063378.42728102,231.624134525816),(-641561.886151018,-1063378.32728102,232.374134525816)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2170.05 | 2170.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641516.695954474,-1063399.61213638,231.815637473611),(-641516.595954474,-1063399.51213638,232.565637473611)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2220.05 | 2220.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641471.40575793,-1063420.79699175,232.180960479596),(-641471.30575793,-1063420.69699175,232.930960479596)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2270.05 | 2270.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641426.115561386,-1063441.98184712,232.720103543793),(-641426.015561386,-1063441.88184712,233.470103543793)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2320.05 | 2320.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641380.825364842,-1063463.16670249,233.433066666135),(-641380.725364842,-1063463.06670249,234.183066666135)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2370.05 | 2370.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641335.535168298,-1063484.35155786,234.317624949942),(-641335.435168297,-1063484.25155786,235.067624949942)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2420.05 | 2420.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641281.186932445,-1063509.7733843,235.452683350397),(-641281.086932444,-1063509.6733843,236.202683350397)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2480.05 | 2480.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641235.8967359,-1063530.95823967,236.398565350732),(-641235.7967359,-1063530.85823967,237.148565350732)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2530.05 | 2530.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641190.606539356,-1063552.14309504,237.304171471537),(-641190.506539356,-1063552.04309504,238.054171471537)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2580.05 | 2580.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641145.316342812,-1063573.32795041,238.05278385793),(-641145.216342812,-1063573.22795041,238.80278385793)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2630.05 | 2630.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641100.026146268,-1063594.51280578,238.637004899339),(-641099.926146268,-1063594.41280578,239.387004899339)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2680.05 | 2680.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641054.735949724,-1063615.69766115,239.056834595783),(-641054.635949724,-1063615.59766115,239.806834595783)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2730.05 | 2730.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641009.44575318,-1063636.88251651,239.312272947259),(-641009.34575318,-1063636.78251651,240.062272947259)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2780.05 | 2780.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-640964.155556636,-1063658.06737188,239.403319953768),(-640964.055556636,-1063657.96737188,240.153319953768)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2830.05 | 2830.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-640918.865360092,-1063679.25222725,239.329975615312),(-640918.765360092,-1063679.15222725,240.079975615312)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2880.05 | 2880.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-640873.575163548,-1063700.43708262,239.09223993189),(-640873.475163547,-1063700.33708262,239.84223993189)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2930.05 | 2930.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-640828.284967004,-1063721.62193799,238.690112903478),(-640828.184967003,-1063721.52193799,239.440112903478)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2980.05 | 2980.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-640782.88969976,-1063742.70497492,238.190171325718),(-640782.78969976,-1063742.60497492,238.940171325718)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3030.05 | 3030.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-640736.726286416,-1063762.502357,237.890096966322),(-640736.626286416,-1063762.402357,238.640096966322)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3080.05 | 3080.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.109956 | 2 | yes | ((-640708.416836638,-1063773.02168817,238.42421430438),(-640708.316836638,-1063772.92168817,238.72421430438)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3110.05 | 3110.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.109956 | 2 | yes | ((-640679.682198288,-1063782.31882018,238.202434631137),(-640679.582198288,-1063782.21882018,238.502434631137)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3140.05 | 3140.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.109956 | 2 | yes | ((-640650.575618302,-1063790.37630776,238.035323273409),(-640650.475618302,-1063790.27630776,238.335323273409)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3170.05 | 3170.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky modre | 0.251327 | 2 | yes | ((-640819.730495626,-1063715.13541656,238.640853425918),(-640819.630495626,-1063715.03541656,239.390853425918)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky modre | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2985.05 | 2985.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11e,f; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky modre | 0.251327 | 2 | yes | ((-640774.417719808,-1063736.11110098,238.140083188917),(-640774.317719808,-1063736.01110098,238.890083188917)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky modre | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3035.05 | 3035.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11e,f; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky modre | 0.109956 | 2 | yes | ((-640700.602185448,-1063765.66076465,238.170846975332),(-640700.502185448,-1063765.56076465,238.470846975332)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky modre | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3115.05 | 3115.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11e,f; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky modre | 0.109956 | 2 | yes | ((-640672.190099592,-1063774.62985877,237.958435659108),(-640672.090099592,-1063774.52985877,238.258435659108)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky modre | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3145.05 | 3145.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11e,f; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky modre | 0.109956 | 2 | yes | ((-640643.419830386,-1063782.37342913,237.797726118884),(-640643.319830386,-1063782.27342913,238.097726118885)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky modre | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3175.05 | 3175.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11e,f; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky modre | 0.251327 | 2 | yes | ((-640832.813657455,-1063719.50358283,238.73772156236),(-640832.713657455,-1063719.40358283,239.48772156236)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky modre | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2975.05 | 2975.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11e,f; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky modre | 0.251327 | 2 | yes | ((-640787.45059387,-1063740.62476558,238.240243242409),(-640787.350593869,-1063740.52476558,238.990243242409)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky modre | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3025.05 | 3025.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11e,f; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky modre | 0.251327 | 2 | yes | ((-640741.398789435,-1063760.63313846,237.918925593521),(-640741.298789435,-1063760.53313846,238.668925593521)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky modre | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3075.05 | 3075.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11e,f; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky modre | 0.109956 | 2 | yes | ((-640713.16573665,-1063771.35294139,238.46663719933),(-640713.06573665,-1063771.25294139,238.76663719933)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky modre | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3105.05 | 3105.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11e,f; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky modre | 0.109956 | 2 | yes | ((-640684.498238845,-1063780.8550819,238.235490658694),(-640684.398238845,-1063780.7550819,238.535490658694)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky modre | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3135.05 | 3135.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11e,f; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky modre | 0.109956 | 2 | yes | ((-640655.449954364,-1063789.1202663,238.060417219182),(-640655.349954364,-1063789.0202663,238.360417219182)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky modre | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3165.05 | 3165.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11e,f; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
trasa-průjezdní a průchozí prostor | 0.06 | 2 | yes | ((-642527.337484443,-1062916.93609144,232.81),(-642527.237484443,-1062916.83609144,232.91)) | ByLayer | 9 | trasa-průjezdní a průchozí prostor | Barva_9 |  |  |  |  | P2 | 191;191;191 | CZ_I3 - Fáze projektu: PDPS; Označení položky: nerelevantni; Název (trasy): Silnice II/322; Staničení od: 1099.96; Staničení do: 1100.09; Označení elementu: průjezdní a průchozí prostor; Označení průjezdného profilu: nerelevantni; Klasifikační systém: nerelevantni; Označení šablony vlastností: I3+E1+Z1+F1
zemní práce-násyp | 3702.35 | 2 | yes | ((-642487.895488569,-1062987.09433928,229.15),(-642401.569790688,-1062930.56342481,231.954975295573)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 1828.04 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1150 | 1234.5 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 18028.2 | 2 | yes | ((-642406.560964346,-1063377.38898907,228.98),(-641569.888051378,-1062967.89238527,232.259031903355)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 2448.49 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1239.5 | 2154.5 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 10669.4 | 2 | yes | ((-641573.947691675,-1063506.87627486,229.793),(-641292.937341979,-1063360.50832533,234.092643471298)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 2035.19 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2159.5 | 2459.71 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 5756.85 | 2 | yes | ((-640736.716424842,-1063808.9996191,232.506472046139),(-640635.946770925,-1063748.59411318,236.869199370114)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 5369.77 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3085.32 | 3180 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 271.711 | 2 | yes | ((-642410.762509366,-1062987.07465442,229.209416559533),(-642397.585529079,-1062966.87296142,231.00287888789)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 79.1214 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1234.5 | 1239.5 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 72.0642 | 2 | yes | ((-641577.330637967,-1063376.52090233,230.231965399943),(-641566.927937478,-1063362.87651181,230.632263077625)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 4.99647 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2154.5 | 2159.5 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 349.347 | 2 | yes | ((-640741.243068555,-1063777.37038204,235.08311247479),(-640725.568010195,-1063747.06001678,236.90910913149)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 98.1335 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3080.23 | 3085.32 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 36.6724 | 1 | no | ((-642410.178438479,-1062985.8515272,230.093421157171),(-642403.868009099,-1062979.93288918,231.96)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 2.33898 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1234.53 | 1239.5 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 23.3959 | 1 | no | ((-642404.026068634,-1062973.04890802,230.586581822832),(-642398.240666875,-1062968.21881202,231.96)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 1.43578 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1234.5 | 1239.5 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 17.457 | 1 | no | ((-641571.84506515,-1063365.09687306,230.539677181041),(-641566.370315965,-1063360.9565528,231.59)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 1.04226 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2154.5 | 2159.5 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 18.037 | 1 | no | ((-641577.13367732,-1063376.40317091,230.435689251783),(-641571.553016569,-1063372.03642683,231.59)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 1.07484 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2154.5 | 2159.5 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 113.9 | 1 | no | ((-640741.26517145,-1063777.36949237,234.9),(-640732.054087443,-1063763.4674947,237.81)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 7.59429 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3080.23 | 3085.32 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 34.5065 | 1 | no | ((-640732.596003887,-1063754.61260409,235.35),(-640725.697169168,-1063747.27229857,237.61)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 2.01263 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3080.23 | 3085.32 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-sanace | 49240.5 | 1 | no | ((-642487.895488569,-1063808.9996191,228.48),(-640635.946770925,-1062930.56342481,237.271497018154)) | ByLayer | 40 | zemní práce-sanace | Barva_40 | úprava podloží hydraulickými pojivy | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 255;165;0 | 11949.1 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1150 | 3180 | sanace | 215663 | I1+S1+E1+Z1+M3+F1
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-641028.321006995,-1063630.04397872,239.21),(-641028.242795585,-1063629.96576731,241.56052612008)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2760.04 | 2760.04 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-641022.75574549,-1063618.14624408,239.21),(-641022.67753408,-1063618.06803267,241.56052612008)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2760.04 | 2760.04 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-641462.682805823,-1063425.76272758,232),(-641462.604594413,-1063425.68451617,234.35052612008)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2280.04 | 2280.04 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
záchytné systémy-svodidlo | 10.8761 | 2 | yes | ((-640650.111430932,-1063783.49374173,237.459624845374),(-640638.525745046,-1063780.5471946,237.829864871714)) | ByLayer | 4 | záchytné systémy-svodidlo | Barva_4 |  |  |  |  | P2 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | záchytné systémy | 3168 | 3180 | svodidlo | 9113B1 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: svodidlo; Stavební výrobek: ocelové svodidlo H1; Specifikace: TP 203; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 12
záchytné systémy-svodidlo | 11.0252 | 2 | yes | ((-640652.494901781,-1063792.80987036,237.672124845747),(-640640.750117058,-1063789.8238405,238.042361142649)) | ByLayer | 4 | záchytné systémy-svodidlo | Barva_4 |  |  |  |  | P2 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | záchytné systémy | 3168 | 3180 | svodidlo | 9113B1 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: svodidlo; Stavební výrobek: ocelové svodidlo H1; Specifikace: TP 203; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 12
odvodnění-zpevněné příkopy a odvodňovací žlaby | 356.489 | 1 | no | ((-641209.701857479,-1063646.62661781,236.170000000011),(-640991.616636104,-1063545.21973661,239.118418711187)) | ByLayer | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 |  |  |  |  | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2560 | 2800 | zpevněné příkopy a odvodňovací žlaby | 935842 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: rigol; Stavební výrobek: rigol š. 60 cm v bet. loži C20/25nXF3; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 240
odvodnění-zpevněné příkopy a odvodňovací žlaby | 319.358 | 1 | no | ((-641181.504191414,-1063635.98094565,236.834204380305),(-640986.637036933,-1063543.941567,239.118418711186)) | ByLayer | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 |  |  |  |  | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2585 | 2800 | zpevněné příkopy a odvodňovací žlaby | 935842 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: rigol; Stavební výrobek: rigol š. 60 cm v bet. loži C20/25nXF3; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 215
odvodnění-zpevněné příkopy a odvodňovací žlaby | 296.988 | 1 | no | ((-640991.851899469,-1063731.36311588,238.090608477924),(-640810.453070719,-1063646.04801919,239.153558245176)) | ByLayer | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 |  |  |  |  | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2800.05 | 3000 | zpevněné příkopy a odvodňovací žlaby | 935842 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: rigol; Stavební výrobek: rigol š. 60 cm v bet. loži C20/25nXF3; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 199.95
odvodnění-zpevněné příkopy a odvodňovací žlaby | 296.981 | 1 | no | ((-640986.872300305,-1063720.71768848,238.090608945102),(-640805.47895473,-1063635.40234702,239.153558245177)) | ByLayer | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 |  |  |  |  | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2800.05 | 3000 | zpevněné příkopy a odvodňovací žlaby | 935842 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: rigol; Stavební výrobek: rigol š. 60 cm v bet. loži C20/25nXF3; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 199.95
odvodnění-zpevněné příkopy a odvodňovací žlaby | 64.7297 | 1 | no | ((-640805.71282256,-1063737.82524147,237.161792343591),(-640765.206106613,-1063720.14138244,238.240107590429)) | ByLayer | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 |  |  |  |  | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 3000.05 | 3043.88 | zpevněné příkopy a odvodňovací žlaby | 935842 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: rigol; Stavební výrobek: rigol š. 60 cm v bet. loži C20/25nXF3; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 43.83
odvodnění-zpevněné příkopy a odvodňovací žlaby | 59.3828 | 1 | no | ((-640810.687394992,-1063750.0164131,236.882071696818),(-640774.872368169,-1063730.7879465,238.239607545574)) | ByLayer | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 |  |  |  |  | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 3000.05 | 3040 | zpevněné příkopy a odvodňovací žlaby | 935842 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: rigol; Stavební výrobek: rigol š. 60 cm v bet. loži C20/25nXF3; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 39.95
dopravní značení-svislé dopravní značení | 0.791681 | 2 | yes | ((-641022.829651365,-1063618.46049167,241.01052612008),(-641022.523855693,-1063617.82226029,241.71052612008)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2760 | 2760 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: B21b; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.791681 | 2 | yes | ((-641028.481709575,-1063630.30804297,241.01052612008),(-641028.17430511,-1063629.67054906,241.71052612008)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2760 | 2760 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: B21b; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.791681 | 2 | yes | ((-641462.844202404,-1063426.02647947,233.80052612008),(-641462.535411008,-1063425.38962541,234.50052612008)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2280 | 2280 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: B21a; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
vozovka_chodník-obrusná vrstva | 1226.94 | 1 | no | ((-642987.990274347,-1062721.97643728,232.58510541166),(-642854.322269988,-1062663.24189556,233.013189171712)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 24.2957 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 1995.12 | 1 | no | ((-642989.764201191,-1062729.90969784,232.585090192868),(-642855.942221873,-1062667.10409504,233.013189171712)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 39.6507 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 1232.83 | 1 | no | ((-642987.990274347,-1062721.97643728,232.52510541166),(-642854.322269988,-1062663.24189556,232.973189171712)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 36.4436 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 2001.11 | 1 | no | ((-642989.764201191,-1062729.90969784,232.525090192868),(-642855.942221873,-1062667.10409504,232.973189171712)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 59.4761 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 1235.77 | 1 | no | ((-642987.990274347,-1062721.97643728,232.45510541166),(-642854.322269988,-1062663.24189556,232.913189171712)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 42.5175 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 2004.1 | 1 | no | ((-642989.764201191,-1062729.90969784,232.455090192868),(-642855.942221873,-1062667.10409504,232.913189171712)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 69.3888 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 1274.03 | 1 | no | ((-642987.990274347,-1062721.97643728,232.25510541166),(-642854.322269988,-1062663.24189556,232.843189171712)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 121.479 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 2042.98 | 1 | no | ((-642989.764201191,-1062729.90969784,232.255090192868),(-642855.942221873,-1062667.10409504,232.843189171712)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 198.254 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 1291.96 | 1 | no | ((-642987.990274347,-1062721.97643728,231.98385541166),(-642854.322269988,-1062663.24189556,232.643189171712)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 158.3 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 2063.26 | 1 | no | ((-642989.764201191,-1062729.90969784,231.98383714911),(-642855.942221873,-1062667.10409504,232.643189171712)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 265.696 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 15.1193 | 1 | no | ((-642989.772653541,-1062729.92842203,232.584583863754),(-642859.21302735,-1062670.96684772,232.798662379268)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0579964 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 42.8122 | 1 | no | ((-642989.806198804,-1062730.00273366,232.522574370083),(-642859.21302735,-1062670.96684772,232.758662379268)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.734021 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
