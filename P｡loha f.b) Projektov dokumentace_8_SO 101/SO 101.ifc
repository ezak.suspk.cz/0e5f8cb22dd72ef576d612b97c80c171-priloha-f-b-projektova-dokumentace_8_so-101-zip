Properties of the parts of a building model (IFC4X3_ADD2), part 1 of 21

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: D:\_Projekty\2017_07 - SÚS Obchvat Dašic\4_PDPS\BIM\IFC\SO 101.ifc
Time: 2025-07-02T08:05:45
Author: Michal Švarc
Organization: DESKTOP-47J51D1
Written by: GeometryGymIFCcore v24.8.23.0 by Geometry Gym Pty Ltd built 2024-08-23T03:53:20
Made in: Civil 3D 2024 IfcInfra Plugin v13.6.170.0
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcBuiltElement (2093)
In: UnknownName
Properties - ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no; IsNull: no; UsesGraphicsCache: yes; CloneMeForDragging: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
General - LinetypeScale: 1; Visible: yes
Geometry - IsPlanar: no
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | Linetype | ColorIndex | Layer | PlotStyleName | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | Skupina elementů | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Tloušťka
2 x vozovka_chodník-zpevnění krajnic | 33.5363 | 1 | no | ((-640066.213156889,-1063693.61281614,233.691097824274),(-640057.194088468,-1063688.68729258,234.027274393576)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 2.07322 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 848.223 | 1 | no | ((-640566.788107574,-1063833.47325024,230.04),(-640062.666271807,-1063676.38378481,236.85)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 24.642 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.25469 | 3.77012 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-horní podkladní vrstva | 846.121 | 1 | no | ((-640566.788107574,-1063833.47325024,229.99),(-640062.666271807,-1063676.38378481,236.79)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | TP 210 | P2 | 128;128;128 | 20.535 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.25469 | 3.77012 | horní podkladní vrstva | 56360 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-spodní podkladní vrstva | 883.962 | 1 | no | ((-640566.788107574,-1063833.47325024,229.76),(-640062.666271807,-1063676.38378481,236.74)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 94.461 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.25469 | 3.77012 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
vozovka_chodník-obrusná vrstva | 77.5849 | 1 | no | ((-640065.570936156,-1063697.56854977,233.942095788511),(-640055.640167156,-1063690.32215924,234.133524393575)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.53 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 77.5849 | 1 | no | ((-640064.017014844,-1063701.5242834,233.942095788512),(-640054.086245843,-1063694.27789287,234.133524393577)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.53 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 78.1149 | 1 | no | ((-640065.570936156,-1063697.56854977,233.882095788511),(-640055.640167156,-1063690.32215924,234.093524393574)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.295 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 78.1149 | 1 | no | ((-640064.017014844,-1063701.5242834,233.882095788511),(-640054.086245843,-1063694.27789287,234.093524393574)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.295 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 78.3799 | 1 | no | ((-640065.570936156,-1063697.56854977,233.812095788513),(-640055.640167156,-1063690.32215924,234.033524393574)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.6775 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 78.3799 | 1 | no | ((-640064.017014844,-1063701.5242834,233.812095788512),(-640054.086245843,-1063694.27789287,234.033524393578)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.6775 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 81.8249 | 1 | no | ((-640065.570936156,-1063697.56854977,233.612095788513),(-640055.640167156,-1063690.32215924,233.963524393574)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 7.65 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 81.8249 | 1 | no | ((-640064.017014844,-1063701.5242834,233.612095788512),(-640054.086245843,-1063694.27789287,233.963524393574)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 7.65 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 83.4367 | 1 | no | ((-640065.570936156,-1063697.56854977,233.340845788512),(-640055.640167156,-1063690.32215924,233.763524393574)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 9.96891 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 83.4367 | 1 | no | ((-640064.017014844,-1063701.5242834,233.340845788512),(-640054.086245843,-1063694.27789287,233.763524393575)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 9.96891 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 0.950736 | 1 | no | ((-640062.463093531,-1063701.54313425,233.941589459398),(-640054.078840708,-1063698.2336265,234.027274393607)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00364557 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 2.70011 | 1 | no | ((-640062.463093531,-1063701.61794857,233.879579965727),(-640054.049451578,-1063698.2336265,233.987274393576)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0461392 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 4.39821 | 1 | no | ((-640062.463093531,-1063701.69747561,233.807443889778),(-640054.018211165,-1063698.2336265,233.927274393582)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.106063 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 13.3054 | 1 | no | ((-640062.463093531,-1063702.08065897,233.597151681968),(-640053.867686167,-1063698.2336265,233.857274393577)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.795456 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 41.9445 | 1 | no | ((-640062.463093531,-1063703.48465501,233.277659688476),(-640053.316157785,-1063698.2336265,233.657274393576)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 3.56731 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 33.5363 | 1 | no | ((-640062.463093531,-1063703.15915006,233.691097824265),(-640053.444025111,-1063698.2336265,234.027274393607)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 2.07322 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 32.8068 | 1 | no | ((-640062.396827312,-1063703.26527863,233.43479804585),(-640053.402334879,-1063698.40231684,233.862296024372)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 2.77855 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.77471 | 3.78371 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 175.956 | 1 | no | ((-640069.312816463,-1063692.26395234,229.900916186198),(-640057.723959384,-1063680.82897837,233.76085871505)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 12.6677 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.77471 | 3.78371 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 0.950736 | 1 | no | ((-640065.578341291,-1063693.61281614,233.941589459399),(-640057.194088468,-1063690.30330839,234.027274393576)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00364557 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 2.70011 | 1 | no | ((-640065.607730421,-1063693.61281614,233.879579965688),(-640057.194088468,-1063690.22849406,233.987274393576)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0461392 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 4.39821 | 1 | no | ((-640065.638970835,-1063693.61281614,233.807443889777),(-640057.194088468,-1063690.14896703,233.927274393581)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.106063 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 13.3054 | 1 | no | ((-640065.789495833,-1063693.61281614,233.597151681939),(-640057.194088468,-1063689.76578367,233.857274393576)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.795456 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 41.9445 | 1 | no | ((-640066.341024215,-1063693.61281614,233.277659688483),(-640057.194088468,-1063688.36178763,233.657274393576)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 3.56731 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77471 | 3.78371 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-zemní krajnice a dosypávky | 32.8068 | 1 | no | ((-640066.254847121,-1063693.4441258,233.434798045854),(-640057.260354687,-1063688.581164,233.862296024359)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 2.77855 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.77471 | 3.78371 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 1045.05 | 1 | no | ((-639463.736826729,-1063512.05528255,230.388845997022),(-639392.184733591,-1063497.20825568,230.964542530046)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 20.768 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.477 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 608.902 | 1 | no | ((-639462.759419162,-1063516.26892885,230.46188587161),(-639391.817504122,-1063504.35330102,230.964542530046)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 12.0539 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.477 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 1048.21 | 1 | no | ((-639463.736826729,-1063512.05528255,230.328845997022),(-639392.184733591,-1063497.20825568,230.924542530046)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 31.152 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.477 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 611.909 | 1 | no | ((-639462.759419162,-1063516.26892885,230.40188587161),(-639391.817504122,-1063504.35330102,230.924542530046)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 18.0808 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.477 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 1049.78 | 1 | no | ((-639463.736826729,-1063512.05528255,230.258845997022),(-639392.184733591,-1063497.20825568,230.864542530046)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 36.344 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.477 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 613.412 | 1 | no | ((-639462.759419162,-1063516.26892885,230.33188587161),(-639391.817504122,-1063504.35330102,230.864542530046)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 21.0943 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.477 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 1070.3 | 1 | no | ((-639463.736826729,-1063512.05528255,230.058845997022),(-639392.184733591,-1063497.20825568,230.794542530046)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 103.84 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.477 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 632.952 | 1 | no | ((-639462.759419162,-1063516.26892885,230.13188587161),(-639391.817504122,-1063504.35330102,230.794542530046)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 60.2694 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.477 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 1081.17 | 1 | no | ((-639463.736826729,-1063512.05528255,229.772985605056),(-639392.184733591,-1063497.20825568,230.594542530046)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 139.284 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.477 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 642.104 | 1 | no | ((-639462.759419162,-1063516.26892885,229.860635871608),(-639391.817504122,-1063504.35330102,230.594542530046)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 78.5372 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.477 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 2.53048 | 1 | no | ((-639415.678710209,-1063510.85772851,230.461379542496),(-639391.815754108,-1063508.58740571,230.622518408713)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00970683 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.45297 | 4.477 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 7.17323 | 1 | no | ((-639415.678710209,-1063510.93769428,230.399370048825),(-639391.80880874,-1063508.58740571,230.582518408713)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.122872 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.45297 | 4.477 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 11.6728 | 1 | no | ((-639415.678710209,-1063511.02269728,230.327233972875),(-639391.80142587,-1063508.58740571,230.522518408713)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.282439 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.45297 | 4.477 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 35.1329 | 1 | no | ((-639415.678710209,-1063511.43226532,230.116941765083),(-639391.765853145,-1063508.58740571,230.452518408713)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 2.11802 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.45297 | 4.477 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 102.131 | 1 | no | ((-639415.678710209,-1063512.7726837,229.802282218436),(-639391.649432114,-1063508.58740571,230.252518408713)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 8.61094 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.45297 | 4.477 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 166.532 | 1 | no | ((-639415.647129316,-1063514.89949445,229.392386429579),(-639391.503907727,-1063509.30011851,230.414808101784)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 11.1854 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.45297 | 4.477 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 62.256 | 1 | no | ((-639415.719726642,-1063512.05572171,230.25378682855),(-639391.712066268,-1063508.58740571,230.622518408733)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 3.20048 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.45297 | 4.477 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 69.5775 | 1 | no | ((-639415.660339822,-1063512.36918475,229.96451733716),(-639391.684477711,-1063508.76796704,230.457540039497)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 4.01409 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.45297 | 4.477 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 398.893 | 1 | no | ((-639462.111355971,-1063521.21172608,229.247523296689),(-639415.306124868,-1063511.55346325,230.650582223035)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 27.449 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.406 | 4.45293 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 4.94066 | 1 | no | ((-639462.204725684,-1063516.28900877,230.582219690411),(-639415.717692495,-1063510.84176109,230.858292530045)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0189564 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.45293 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 13.9978 | 1 | no | ((-639462.204725684,-1063516.36870096,230.52021019674),(-639415.709543144,-1063510.84176109,230.818292530045)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.239935 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.45293 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 22.7716 | 1 | no | ((-639462.204725684,-1063516.45341314,230.448074120791),(-639415.700880448,-1063510.84176109,230.758292530045)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.551534 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.45293 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 68.4377 | 1 | no | ((-639462.204725684,-1063516.86157994,230.237781912998),(-639415.659141173,-1063510.84176109,230.688292530045)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 4.13599 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.45293 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 198.752 | 1 | no | ((-639462.204725684,-1063518.19741241,229.923122366352),(-639415.522538493,-1063510.84176109,230.488292530045)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 16.8151 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.45293 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 121.109 | 1 | no | ((-639462.204725684,-1063517.47873869,230.374626976462),(-639415.596030312,-1063510.84176109,230.858292530045)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 6.24979 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.45293 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 135.549 | 1 | no | ((-639462.181071051,-1063517.79529394,230.085357485076),(-639415.563659264,-1063511.02206639,230.693314160825)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 7.83856 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.406 | 4.45293 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 5317.49 | 1 | no | ((-639393.11360813,-1063535.33000482,229.08271371927),(-638911.106531391,-1063491.41536543,230.608135871616)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 105.529 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.96 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 4140.29 | 1 | no | ((-639392.184733591,-1063539.48182764,229.082713719264),(-638912.014753432,-1063498.36924003,230.608135871616)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 82.0008 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.96 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 5337.15 | 1 | no | ((-639393.11360813,-1063535.33000482,229.02271371927),(-638911.106531391,-1063491.41536543,230.568135871616)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 158.294 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.96 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 4159.76 | 1 | no | ((-639392.184733591,-1063539.48182764,229.022713719264),(-638912.014753432,-1063498.36924003,230.568135871616)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 123.001 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.96 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 5346.97 | 1 | no | ((-639393.11360813,-1063535.33000482,228.95271371927),(-638911.106531391,-1063491.41536543,230.508135871616)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 184.677 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.96 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 4169.49 | 1 | no | ((-639392.184733591,-1063539.48182764,228.952713719264),(-638912.014753432,-1063498.36924003,230.508135871616)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 143.501 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.96 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 5474.74 | 1 | no | ((-639393.11360813,-1063535.33000482,228.75271371927),(-638911.106531391,-1063491.41536543,230.438135871616)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 527.647 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.96 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 4296.01 | 1 | no | ((-639392.184733591,-1063539.48182764,228.752713719264),(-638912.014753432,-1063498.36924003,230.438135871616)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 410.004 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.96 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 5537.8 | 1 | no | ((-639393.11360813,-1063535.33000482,228.481463719271),(-638911.106531391,-1063491.41536543,230.238135871616)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 700.818 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.96 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 4355.28 | 1 | no | ((-639392.184733591,-1063539.48182764,228.481463719264),(-638912.014753432,-1063498.36924003,230.238135871616)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 534.277 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.96 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 50.8445 | 1 | no | ((-639391.817504122,-1063539.50161294,229.08220739015),(-638912.922975472,-1063502.61923988,230.50188587161)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.195097 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.96 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 143.978 | 1 | no | ((-639391.817504122,-1063539.58013588,229.020197896479),(-638912.922975472,-1063502.61923988,230.46188587161)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.4696 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.96 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 234.159 | 1 | no | ((-639391.817504122,-1063539.66360514,228.94806182053),(-638912.922975472,-1063502.61923988,230.40188587161)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 5.67674 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.96 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 702.755 | 1 | no | ((-639391.817504122,-1063540.06578324,228.737769612738),(-638912.922975472,-1063502.61923988,230.33188587161)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 42.5699 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.96 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 2038.99 | 1 | no | ((-639391.817504122,-1063541.3820161,228.423110066092),(-638912.922975472,-1063502.61923988,230.13188587161)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 173.071 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.96 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 4594.65 | 1 | no | ((-639391.755689603,-1063544.02855646,228.060011016561),(-638913.075853477,-1063503.33462826,230.294175564603)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 320.3 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.477 | 4.96 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 1244.03 | 1 | no | ((-639391.817504122,-1063540.6738869,228.874614676204),(-638912.922975472,-1063502.61923988,230.50188587161)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 64.3262 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.96 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 1392.03 | 1 | no | ((-639391.8018438,-1063540.98579759,228.585345184816),(-638912.96170616,-1063502.80047906,230.336907502393)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 80.6788 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.477 | 4.96 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 50.1479 | 1 | no | ((-639383.502484912,-1063531.178182,229.082207390156),(-638911.102203303,-1063491.39513551,230.291285651403)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.192436 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.48658 | 4.96 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 141.996 | 1 | no | ((-639383.508950583,-1063531.178182,229.020197896485),(-638911.085026208,-1063491.314848,230.251285651403)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.43509 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.48658 | 4.96 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 230.94 | 1 | no | ((-639383.515823541,-1063531.178182,228.948061820536),(-638911.06676709,-1063491.22950301,230.191285651403)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 5.59798 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.48658 | 4.96 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 693.238 | 1 | no | ((-639383.548939362,-1063531.178182,228.737769612744),(-638910.978789584,-1063490.81828714,230.121285651403)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 41.9883 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.48658 | 4.96 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 2030.51 | 1 | no | ((-639383.664385127,-1063531.178182,228.423110066099),(-638910.690860222,-1063489.41105986,229.921285651403)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 174.249 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.48658 | 4.96 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 4701.26 | 1 | no | ((-639383.826328831,-1063530.47931943,228.060011016568),(-638910.17266082,-1063486.03999012,230.341213763449)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 328.428 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.48658 | 4.96 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 1227.79 | 1 | no | ((-639383.654233703,-1063531.178182,228.87461467621),(-638910.845765327,-1063490.19651812,230.291285651403)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 63.4731 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.48658 | 4.96 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 1389.64 | 1 | no | ((-639383.631760026,-1063531.00112953,228.585345184823),(-638910.777534052,-1063489.81618222,230.126307282187)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 81.3581 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.48658 | 4.96 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 40.9935 | 1 | no | ((-639390.508330774,-1063492.68085807,229.193723937845),(-639383.613622041,-1063489.49607283,230.116616029633)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 2.6329 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.48 | 4.48653 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 0.694349 | 1 | no | ((-639390.106216774,-1063493.38536532,230.25105544657),(-639383.556052355,-1063492.82304133,230.324326336596)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00266196 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.48 | 4.48653 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 1.97416 | 1 | no | ((-639390.113011981,-1063493.38536532,230.189045952899),(-639383.556052355,-1063492.74292227,230.284326336596)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0336856 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.48 | 4.48653 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 3.21765 | 1 | no | ((-639390.120235233,-1063493.38536532,230.11690987695),(-639383.556052355,-1063492.65775634,230.224326336596)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0774394 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.48 | 4.48653 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 9.76346 | 1 | no | ((-639390.155038867,-1063493.38536532,229.906617669157),(-639383.556052355,-1063492.24740324,230.154326336596)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.580841 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.48 | 4.48653 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 30.0772 | 1 | no | ((-639390.276368553,-1063493.38536532,229.556822987377),(-639383.556052355,-1063490.81686257,229.954326336596)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 2.64601 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.48 | 4.48653 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 17.4995 | 1 | no | ((-639390.305700649,-1063493.3936831,230.043462732616),(-639383.556052355,-1063491.62693875,230.324326336616)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.878049 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.48 | 4.48653 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 20.6499 | 1 | no | ((-639390.242080649,-1063493.20477494,229.719058106101),(-639383.570637276,-1063491.22113495,230.159347967372)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 1.24368 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.48 | 4.48653 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
2 x vozovka_chodník-obrusná vrstva | 2.16229 | 1 | no | ((-640566.801669476,-1063818.22835264,234.632176507229),(-640563.989846127,-1063806.01563658,236.83)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0125029 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.25468 | 3.25805 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
2 x vozovka_chodník-ložní vrstva | 4.00275 | 1 | no | ((-640566.834670104,-1063818.22835264,234.576093173896),(-640563.989846127,-1063806.01563658,236.77)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | TP 210 | P2 | 128;128;128 | 0.0626454 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.25465 | 3.25805 | ložní vrstva | 53630 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-obrusná vrstva | 2.4171 | 1 | no | ((-640566.702270749,-1063832.99414733,231.237500000015),(-640564.889837502,-1063818.22460965,234.694676507229)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0139433 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.25802 | 3.25809 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 4.50864 | 1 | no | ((-640566.77776499,-1063832.99414733,231.181416666682),(-640564.889837502,-1063818.21550171,234.634676507229)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | TP 210 | P2 | 128;128;128 | 0.0701039 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.25794 | 3.25809 | ložní vrstva | 53630 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-horní podkladní vrstva | 4.81366 | 1 | no | ((-640566.827405039,-1063832.99414733,231.177416666682),(-640564.889837502,-1063818.20951292,234.584676507229)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 2.36325e-11 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.25789 | 3.25809 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
zemní práce-rozprostření ornice (ohumusovani) | 108.673 | 1 | no | ((-640571.404190855,-1063832.93425946,231.078668753397),(-640565.386237989,-1063817.44243337,234.654676507229)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 7.52963 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.25163 | 3.25761 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 26.064 | 1 | no | ((-640567.1948655,-1063832.99414733,230.960000000015),(-640564.889837502,-1063818.16518093,234.584676507229)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.21441 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.2573 | 3.25809 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
zemní práce-zemní krajnice a dosypávky | 22.0017 | 1 | no | ((-640567.245629248,-1063832.98190029,230.960000000015),(-640564.991351137,-1063818.13677334,234.586177038862)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.582068 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.2573 | 3.25799 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 17.8319 | 1 | no | ((-640567.167646206,-1063832.99414733,231.159680510383),(-640564.889837502,-1063818.16846478,234.694676507229)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.677056 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.25756 | 3.25809 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-horní podkladní vrstva | 4.24645 | 1 | no | ((-640566.856369146,-1063818.22835264,234.572093173896),(-640563.989846127,-1063806.01563658,236.72)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 8.37981e-12 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.25464 | 3.25805 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 22.396 | 1 | no | ((-640567.016996311,-1063818.22835264,234.354676507229),(-640563.989846127,-1063806.01563658,236.72)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.06231 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.25452 | 3.25805 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
zemní práce-zemní krajnice a dosypávky | 18.9423 | 1 | no | ((-640567.096353398,-1063818.21610561,234.354676507229),(-640564.092091282,-1063806.10775563,236.721500531633)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.518041 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.25446 | 3.25795 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 16.7992 | 1 | no | ((-640567.352282686,-1063818.22835264,234.554357017597),(-640563.989846127,-1063806.01563658,236.83)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.652466 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.25428 | 3.25805 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 2.18705 | 1 | no | ((-640560.939338613,-1063818.88281891,234.557957046864),(-640556.201690842,-1063807.29232893,236.78)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0126468 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.26195 | 3.26529 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 4.0486 | 1 | no | ((-640560.939338613,-1063818.89192685,234.501873713531),(-640556.185785227,-1063807.29232893,236.72)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | TP 210 | P2 | 128;128;128 | 0.0633694 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.26195 | 3.26531 | ložní vrstva | 53630 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-horní podkladní vrstva | 4.29527 | 1 | no | ((-640560.939338613,-1063818.89791564,234.497873713531),(-640556.17532674,-1063807.29232893,236.67)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 6.69803e-12 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.26195 | 3.26533 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 21.0239 | 1 | no | ((-640560.939338613,-1063818.94224763,234.280457046864),(-640556.09790779,-1063807.29232893,236.67)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.09562 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.26195 | 3.26544 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
zemní práce-zemní krajnice a dosypávky | 19.2897 | 1 | no | ((-640560.837824977,-1063818.97065522,234.280457046864),(-640556.059659327,-1063807.39231683,236.671500531633)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.563473 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.26205 | 3.2655 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 16.9739 | 1 | no | ((-640560.939338613,-1063818.93896378,234.480137557232),(-640555.936306737,-1063807.29232893,236.78)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.659172 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.26195 | 3.26568 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 2.38868 | 1 | no | ((-640562.700041821,-1063833.47699323,231.2375),(-640560.908313583,-1063818.87907591,234.620457046864)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0137812 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.26191 | 3.26198 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 4.4548 | 1 | no | ((-640562.700041821,-1063833.48610118,231.181416666667),(-640560.832819342,-1063818.87907591,234.560457046864)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | TP 210 | P2 | 128;128;128 | 0.0692891 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.26191 | 3.26206 | ložní vrstva | 53630 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-horní podkladní vrstva | 4.75529 | 1 | no | ((-640562.700041821,-1063833.49208996,231.177416666667),(-640560.783179293,-1063818.87907591,234.510457046864)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 1.15947e-11 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.26191 | 3.26211 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
zemní práce-rozprostření ornice (ohumusovani) | 118.57 | 1 | no | ((-640562.203641334,-1063833.55678971,230.984977876761),(-640554.064771294,-1063818.93896378,234.580457046864)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 8.25691 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.26239 | 3.26872 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 23.8428 | 1 | no | ((-640562.700041821,-1063833.53642195,230.96),(-640560.264096121,-1063818.87907591,234.510457046864)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.2145 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.26191 | 3.2627 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
zemní práce-zemní krajnice a dosypávky | 21.816 | 1 | no | ((-640562.598528185,-1063833.54589115,230.96),(-640560.180253111,-1063818.89132295,234.511957578497)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.592759 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.26201 | 3.2627 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 17.6183 | 1 | no | ((-640562.700041821,-1063833.5331381,231.159680510368),(-640560.442938126,-1063818.87907591,234.620457046864)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.669187 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.26191 | 3.26244 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 1.87703 | 1 | no | ((-640087.495929169,-1063689.35121965,230.1375),(-640083.239138993,-1063678.57755607,232.574044127635)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0108402 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.7598 | 3.75983 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 3.49609 | 1 | no | ((-640087.566705775,-1063689.37902265,230.081416666667),(-640083.239138993,-1063678.57755607,232.514044127635)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | TP 210 | P2 | 128;128;128 | 0.0545019 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.75972 | 3.75983 | ložní vrstva | 53630 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
zemní práce-rozprostření ornice (ohumusovani) | 72.1482 | 1 | no | ((-640088.271612921,-1063691.31668836,229.879066294833),(-640083.70451942,-1063678.76037035,232.534044127635)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 4.96125 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.75442 | 3.75933 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 18.2708 | 1 | no | ((-640087.957741679,-1063689.61934961,229.86),(-640083.239138993,-1063678.57755607,232.464044127635)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 0.945506 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.75906 | 3.75983 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
