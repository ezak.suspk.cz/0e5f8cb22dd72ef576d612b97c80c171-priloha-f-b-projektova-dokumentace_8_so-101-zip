Properties of the parts of a building model (IFC4X3_ADD2), part 7 of 21

# IfcBuiltElement (2093)
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | Linetype | ColorIndex | Layer | PlotStyleName | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | Skupina elementů | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Tloušťka
vozovka_chodník-obrusná vrstva | 20.5725 | 1 | no | ((-642184.201344974,-1063169.3587993,231.613634626955),(-642007.646958127,-1063086.75972686,232.612686336949)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0789489 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1482.8 | 1677.71 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 1.97922 | 1 | no | ((-641942.072230486,-1063207.97786072,232.758013273465),(-641925.084917846,-1063200.01757652,232.81804036222)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00759266 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1750.11 | 1768.85 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 26.1954 | 1 | no | ((-641215.874191538,-1063644.87190209,236.809407190239),(-640991.067826009,-1063539.70257676,239.408418711187)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.100527 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2551.83 | 2800 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 58.2621 | 1 | no | ((-642184.23540164,-1063169.43160759,231.551625133285),(-642007.646958127,-1063086.75972686,232.572686336949)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.999197 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1482.8 | 1677.71 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 5.6124 | 1 | no | ((-641942.106287152,-1063208.05066901,232.696003779794),(-641925.084917846,-1063200.01757652,232.77804036222)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0960946 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1750.11 | 1768.85 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 74.1854 | 1 | no | ((-641215.908248204,-1063644.94471038,236.747397696568),(-640991.067826009,-1063539.70257676,239.368418711187)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.27229 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2551.83 | 2800 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 94.7614 | 1 | no | ((-642184.271603608,-1063169.50900223,231.479489057335),(-642007.646958127,-1063086.75972686,232.512686336949)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.29692 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1482.8 | 1677.71 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 9.1346 | 1 | no | ((-641942.14248912,-1063208.12806365,232.623867703844),(-641925.084917846,-1063200.01757652,232.71804036222)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.220899 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1750.11 | 1768.85 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 120.659 | 1 | no | ((-641215.944450172,-1063645.02210502,236.675261620619),(-640991.067826009,-1063539.70257676,239.308418711187)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.92469 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2551.83 | 2800 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 284.491 | 1 | no | ((-642184.446034755,-1063169.88191112,231.269196849543),(-642007.646958127,-1063086.75972686,232.442686336949)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 17.2265 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1482.8 | 1677.71 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 27.5196 | 1 | no | ((-641942.316920266,-1063208.50097255,232.413575496052),(-641925.084917846,-1063200.01757652,232.64804036222)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 1.6567 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1750.11 | 1768.85 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 362.212 | 1 | no | ((-641216.118881319,-1063645.39501391,236.464969412827),(-640991.067826009,-1063539.70257676,239.238418711187)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 21.9347 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2551.83 | 2800 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 853.795 | 1 | no | ((-642185.042213549,-1063171.15437537,230.930645411007),(-642007.646958127,-1063086.75972686,232.242686336949)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 75.5082 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1482.8 | 1677.71 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 82.8103 | 1 | no | ((-641942.912125702,-1063209.7734368,232.075942976435),(-641925.084917846,-1063200.01757652,232.44804036222)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 7.26175 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1750.11 | 1768.85 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 654.986 | 1 | no | ((-641216.689752799,-1063645.86196835,236.150309866181),(-640991.067826009,-1063539.70257676,239.038418711187)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 62.7124 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2551.83 | 2800 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 2402.89 | 1 | no | ((-642186.821749459,-1063175.44163878,230.4434),(-642007.950066126,-1063087.40772849,232.404976029943)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 170.227 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1482.8 | 1677.71 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 236.135 | 1 | no | ((-641944.854146924,-1063213.71800637,231.245325580886),(-641925.172474223,-1063200.61959558,232.610330055213)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 16.3203 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1750.11 | 1768.85 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 423.512 | 1 | no | ((-641217.614283783,-1063646.05374691,235.710671210011),(-640991.370934007,-1063540.31321258,239.200708404181)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 19.1985 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2551.83 | 2800 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 3547.07 | 1 | no | ((-641211.782717348,-1063652.90553632,236.189763528692),(-640991.879205969,-1063545.7810735,241.37263243357)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 261.604 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2560 | 2800 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 503.69 | 1 | no | ((-642184.709779148,-1063170.44575898,231.40604191301),(-642007.646958127,-1063086.75972686,232.612686336949)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 26.0358 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1482.8 | 1677.71 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 49.5767 | 1 | no | ((-641942.678968817,-1063209.16564642,232.550420559519),(-641924.869366223,-1063199.97159395,232.81804036222)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 2.50391 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1750.11 | 1768.85 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 641.539 | 1 | no | ((-641216.462508486,-1063645.95886178,236.601814476293),(-640991.067826009,-1063539.66521095,239.408418711187)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 33.1517 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2551.83 | 2800 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 588.32 | 1 | no | ((-642184.870367173,-1063170.78699235,231.09288052973),(-642007.723748646,-1063086.92389403,232.447707967732)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 35.3861 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1482.8 | 1677.71 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 56.9073 | 1 | no | ((-641942.740279326,-1063209.40605378,232.238178095158),(-641925.161708365,-1063200.18174368,232.653061993003)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 3.40314 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1750.11 | 1768.85 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 711.506 | 1 | no | ((-641216.517906423,-1063646.18609631,236.312544984904),(-640991.144616527,-1063539.86674393,239.24344034197)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 50.7147 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2551.83 | 2800 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 897.568 | 1 | no | ((-642010.500026899,-1063205.72609085,231.028557580333),(-641942.465061434,-1063169.98845553,232.590662036032)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 63.3903 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1677.85 | 1750 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 7.61576 | 1 | no | ((-642007.521999489,-1063199.98993935,232.572736651657),(-641942.161953435,-1063169.40291824,232.798372343038)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0292243 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1677.85 | 1750 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 0.528545 | 1 | no | ((-641575.7728446,-1063373.49390482,231.5996346647),(-641571.235243739,-1063371.35707389,231.64601307762)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00202532 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2154.5 | 2159.5 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 21.5731 | 1 | no | ((-642007.556056155,-1063200.06274764,232.510727157986),(-641942.161953435,-1063169.40291824,232.758372343038)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.36987 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1677.85 | 1750 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 1.50461 | 1 | no | ((-641575.806901267,-1063373.56671311,231.537625171034),(-641571.235243739,-1063371.35707389,231.60601307762)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0256329 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2154.5 | 2159.5 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 35.0922 | 1 | no | ((-642007.592258123,-1063200.14014228,232.438591082037),(-641942.161953435,-1063169.40291824,232.698372343038)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.850244 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1677.85 | 1750 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 2.45391 | 1 | no | ((-641575.843103235,-1063373.64410775,231.465489095084),(-641571.235243739,-1063371.35707389,231.54601307762)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0589241 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2154.5 | 2159.5 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 105.42 | 1 | no | ((-642007.76668927,-1063200.51305117,232.228298874245),(-641942.161953435,-1063169.40291824,232.628372343038)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 6.37668 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1677.85 | 1750 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 7.47037 | 1 | no | ((-641576.017534381,-1063374.01701664,231.255196887265),(-641571.235243739,-1063371.35707389,231.47601307762)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.44192 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2154.5 | 2159.5 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 316.532 | 1 | no | ((-642008.361894705,-1063201.78551542,231.890666354627),(-641942.161953435,-1063169.40291824,232.428372343038)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 27.9506 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1677.85 | 1750 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 21.8871 | 1 | no | ((-641576.588405862,-1063375.23745837,230.940537340633),(-641571.235243739,-1063371.35707389,231.27601307762)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 1.79724 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2154.5 | 2159.5 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 186.997 | 1 | no | ((-642008.163973509,-1063201.07689903,232.365143937714),(-641942.161953435,-1063169.3404539,232.798372343038)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 9.6376 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1677.85 | 1750 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 13.1816 | 1 | no | ((-641576.281278775,-1063374.5808645,231.392041950756),(-641571.235243739,-1063371.35707389,231.646013077624)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.66791 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2154.5 | 2159.5 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 218.003 | 1 | no | ((-642008.190048329,-1063201.4181324,232.05290147335),(-641942.238743953,-1063169.56708541,232.633393973823)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 13.0988 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1677.85 | 1750 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 14.7879 | 1 | no | ((-641576.416559485,-1063374.87007535,231.10277245937),(-641571.312034257,-1063371.52124105,231.481034708419)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.837867 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2154.5 | 2159.5 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 4.89716 | 1 | no | ((-641624.245417133,-1063358.98641709,231.592159795516),(-641582.140879324,-1063339.27755905,231.794432504797)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0187709 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2097 | 2143.47 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 24.8116 | 1 | no | ((-641200.389182289,-1063637.15422328,237.045881187709),(-640987.457819389,-1063537.53952638,239.408418711186)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0952162 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2564.94 | 2800 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 13.8807 | 1 | no | ((-641624.245417133,-1063358.98641709,231.530150301845),(-641582.106822658,-1063339.20506753,231.754432504797)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.237968 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2097 | 2143.47 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 70.2668 | 1 | no | ((-641200.389182289,-1063637.15422328,236.983871694038),(-640987.423762723,-1063537.46671809,239.368418711186)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.20508 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2564.94 | 2800 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 22.5827 | 1 | no | ((-641624.245417133,-1063358.98641709,231.458014225896),(-641582.07062069,-1063339.12804246,231.694432504797)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.547047 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2097 | 2143.47 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 114.286 | 1 | no | ((-641200.389182289,-1063637.15422328,236.911735618088),(-640987.387560755,-1063537.38932345,239.308418711186)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.7702 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2564.94 | 2800 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 67.6649 | 1 | no | ((-641624.245417133,-1063358.98641709,231.247722018103),(-641581.896189543,-1063338.76490321,231.624432504797)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 4.0927 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2097 | 2143.47 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 343.086 | 1 | no | ((-641200.389182289,-1063637.15422328,236.701443410296),(-640987.213129608,-1063537.01641456,239.238418711186)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 20.776 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2564.94 | 2800 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 201.302 | 1 | no | ((-641624.245417133,-1063358.98641709,230.933062471458),(-641581.325318063,-1063337.65083586,231.424432504797)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 17.6405 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2097 | 2143.47 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 635.156 | 1 | no | ((-641200.389182289,-1063637.15422328,236.38678386365),(-640986.994707896,-1063535.79597283,239.038418711186)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 60.3585 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2564.94 | 2800 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 424.718 | 1 | no | ((-641200.157831547,-1063636.50622165,235.829814937841),(-640986.905001929,-1063533.7138415,239.200708404179)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 20.4038 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2564.94 | 2800 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 3323.36 | 1 | no | ((-641181.241621549,-1063635.41960876,236.853967908986),(-640983.570868045,-1063541.8333748,242.026753241239)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 248.103 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2585 | 2800 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 120.716 | 1 | no | ((-641624.308535161,-1063359.02176155,231.38456708157),(-641581.556883738,-1063338.16086421,231.794432504805)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 6.20455 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2097 | 2143.47 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 607.65 | 1 | no | ((-641200.460939547,-1063637.15422328,236.838288473748),(-640986.949385214,-1063536.41900166,239.408418711186)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 31.4004 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2564.94 | 2800 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 138.03 | 1 | no | ((-641624.16811906,-1063358.82224992,231.095297590182),(-641581.497164439,-1063337.99569461,231.629358302247)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 8.12466 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2097 | 2143.47 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 668.647 | 1 | no | ((-641200.312391771,-1063636.99005612,236.549018982374),(-640986.843094426,-1063536.16335585,239.243440341969)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 47.2369 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2564.94 | 2800 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
odvodnění-zpevněné příkopy a odvodňovací žlaby | 734.326 | 1 | no | ((-641181.515206415,-1063737.84901318,236.764204380305),(-640765.193984656,-1063543.91260284,239.079280109906)) | ByLayer | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 |  |  |  |  | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2585 | 3040 | zpevněné příkopy a odvodňovací žlaby | nerelevantni | nerelevantni | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: rigol; Stavební výrobek: lože; Specifikace: C20/25nXF3; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 455
zemní práce-rozprostření ornice (ohumusovani) | 2579.12 | 1 | no | ((-642180.288230355,-1063338.61816766,230.774547325113),(-641622.930157151,-1063076.4370101,232.831255089319)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 193.4 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1483 | 2097 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 63.8382 | 1 | no | ((-642180.591338354,-1063339.26616929,231.754899438814),(-641624.300053034,-1063079.04249926,233.038453206848)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.242691 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1482.8 | 2096.93 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 0.528545 | 1 | no | ((-641572.16283798,-1063365.77622601,231.599634664662),(-641567.625237119,-1063363.63939508,231.646013077623)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00202532 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2154.5 | 2159.5 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 181.475 | 1 | no | ((-642180.591338354,-1063339.26616929,231.694744982887),(-641624.266144987,-1063078.97036778,233.000197034009)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 3.11652 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1482.8 | 2096.93 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 1.50461 | 1 | no | ((-641572.162837981,-1063365.77622601,231.537625171032),(-641567.591180452,-1063363.56658679,231.606013077623)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0256329 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2154.5 | 2159.5 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 295.295 | 1 | no | ((-642180.591338354,-1063339.26616929,231.624580867638),(-641624.230116409,-1063078.89376275,232.94218777475)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 7.16571 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1482.8 | 2096.93 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 2.45391 | 1 | no | ((-641572.16283798,-1063365.77622601,231.465489095083),(-641567.554978484,-1063363.48919215,231.546013077623)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0589241 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2154.5 | 2159.5 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 863.309 | 1 | no | ((-642180.591338354,-1063339.26616929,231.423807186566),(-641624.060268517,-1063078.54118739,232.875551972281)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 52.6532 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1482.8 | 2096.93 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 7.47037 | 1 | no | ((-641572.16283798,-1063365.77622601,231.255196887246),(-641567.380547338,-1063363.11628326,231.476013077623)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.44192 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2154.5 | 2159.5 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 1984.62 | 1 | no | ((-642180.591338354,-1063339.26616929,231.148004398876),(-641623.540182984,-1063077.58910443,232.685280887943)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 129.638 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1482.8 | 2096.93 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 21.8871 | 1 | no | ((-641572.16283798,-1063365.77622601,230.94053734059),(-641566.809675858,-1063361.89584153,231.276013077623)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 1.79724 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2154.5 | 2159.5 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 1458.04 | 1 | no | ((-642180.591338354,-1063339.26616929,231.546839033028),(-641623.791519779,-1063077.95508837,233.038453206848)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 76.6003 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1482.8 | 2096.93 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 13.1816 | 1 | no | ((-641572.16283798,-1063365.77622601,231.392041950705),(-641567.116802944,-1063362.55243539,231.646013077625)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.66791 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2154.5 | 2159.5 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 1693.28 | 1 | no | ((-642180.513448871,-1063339.10091375,231.1890427132),(-641623.70140771,-1063077.58910443,232.875551972281)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 93.7697 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1482.8 | 2096.93 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 14.7879 | 1 | no | ((-641572.086047462,-1063365.61205885,231.102772459348),(-641566.981522234,-1063362.26322455,231.481034708403)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.837867 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2154.5 | 2159.5 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 1716.9 | 1 | no | ((-640989.267113302,-1063725.74238928,238.490608945102),(-640806.306461513,-1063637.15422328,239.549808245177)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 34 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 1716.9 | 1 | no | ((-640991.067826009,-1063729.59201594,238.490652254027),(-640808.105947389,-1063641.00388999,239.549808245177)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 34 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 1725.07 | 1 | no | ((-640989.267113302,-1063725.74238928,238.430608945102),(-640806.306461513,-1063637.15422328,239.509808245177)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 50.9999 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 1725.07 | 1 | no | ((-640991.067826009,-1063729.59201594,238.430652254027),(-640808.105947389,-1063641.00388999,239.509808245177)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 51.0001 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 1729.15 | 1 | no | ((-640989.267113302,-1063725.74238928,238.360608945102),(-640806.306461513,-1063637.15422328,239.449808245177)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 59.4999 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 1729.16 | 1 | no | ((-640991.067826009,-1063729.59201594,238.360652254027),(-640808.105947389,-1063641.00388999,239.449808245177)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 59.5001 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 1782.26 | 1 | no | ((-640989.267113302,-1063725.74238928,238.160608945102),(-640806.306461513,-1063637.15422328,239.379808245177)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 170 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 1782.26 | 1 | no | ((-640991.067826009,-1063729.59201594,238.160652254027),(-640808.105947389,-1063641.00388999,239.379808245177)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 170 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 1807.14 | 1 | no | ((-640989.267113302,-1063725.74238928,237.889354615511),(-640806.306461513,-1063637.15422328,239.179808245177)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 221.531 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 1807.14 | 1 | no | ((-640991.067826009,-1063729.59201594,237.889406586221),(-640808.105947389,-1063641.00388999,239.179808245177)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 221.531 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 21.1105 | 1 | no | ((-640991.076407216,-1063729.61036488,238.490145924913),(-640809.90469992,-1063644.8535567,239.443558245176)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0810136 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 59.7855 | 1 | no | ((-640991.110463882,-1063729.68318726,238.428136431242),(-640809.90469992,-1063644.8535567,239.403558245176)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.02533 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 97.239 | 1 | no | ((-640991.14666585,-1063729.76059688,238.356000355293),(-640809.90469992,-1063644.8535567,239.343558245176)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.35698 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 291.927 | 1 | no | ((-640991.321096997,-1063730.13357793,238.145708147501),(-640809.90469992,-1063644.8535567,239.273558245176)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 17.677 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 517.256 | 1 | no | ((-640991.891968477,-1063730.60061732,237.859406586221),(-640809.90469992,-1063644.8535567,239.073558245176)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 49.8229 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 283.625 | 1 | no | ((-640994.43461037,-1063730.79253753,238.101336974291),(-640810.207539708,-1063645.50155833,240.827943429434)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 10.6627 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2800 | 3000 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 1731.62 | 1 | no | ((-640994.035078239,-1063731.87195019,238.108386500757),(-640810.715408245,-1063646.60935608,240.862178219729)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 128.259 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2800.05 | 3000 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 516.857 | 1 | no | ((-640991.58484139,-1063730.69753489,238.282553210967),(-640809.90469992,-1063644.8535567,239.443558245176)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 26.7166 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 565.29 | 1 | no | ((-640991.720122101,-1063730.92491255,237.86620291299),(-640809.981422488,-1063645.01772386,239.278579875959)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 40.5132 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2800 | 3000 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 21.1101 | 1 | no | ((-640987.466400596,-1063721.89119315,238.490102615988),(-640806.297887899,-1063637.13587789,239.443558245177)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0810117 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 59.7845 | 1 | no | ((-640987.466400596,-1063721.89119315,238.428093122317),(-640806.263861369,-1063637.0630696,239.403558245177)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.02531 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 97.2373 | 1 | no | ((-640987.466400596,-1063721.89119315,238.355957046368),(-640806.227691435,-1063636.98567496,239.343558245177)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.35694 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 291.922 | 1 | no | ((-640987.466400596,-1063721.89119315,238.145664838576),(-640806.053414636,-1063636.61276607,239.273558245177)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 17.6766 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 517.246 | 1 | no | ((-640987.466400596,-1063721.89119315,237.859354615511),(-640805.835183677,-1063635.39232434,239.073558245177)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 49.822 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 285.1 | 1 | no | ((-640987.163292597,-1063721.24306613,238.101337441469),(-640805.74555961,-1063629.35782365,241.645560505029)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 10.6674 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2800 | 3000 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 2301.79 | 1 | no | ((-640986.609730439,-1063720.15624297,238.108386967931),(-640804.852457243,-1063628.84594371,242.167382419448)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 171.426 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2800.05 | 3000 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 516.846 | 1 | no | ((-640987.466400596,-1063721.89119315,238.282509902042),(-640805.789903622,-1063636.04891821,239.443558245177)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 26.7161 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2800 | 3000 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 565.278 | 1 | no | ((-640987.389610078,-1063721.72699422,237.866151657474),(-640805.683706887,-1063635.75970736,239.27857987596)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 40.5123 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2800 | 3000 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 102.513 | 1 | no | ((-640749.802890959,-1063756.501641,237.730816177918),(-640737.178754876,-1063748.04178041,237.996593198168)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.02367 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 103.015 | 1 | no | ((-640751.447523757,-1063760.44424832,237.837063747876),(-640738.765900396,-1063751.96062478,238.022737049344)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.03412 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 103.159 | 1 | no | ((-640749.802890959,-1063756.501641,237.670816177918),(-640737.178754876,-1063748.04178041,237.956593198168)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 3.03551 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 103.663 | 1 | no | ((-640751.447523757,-1063760.44424832,237.777063747876),(-640738.765900396,-1063751.96062478,237.982737049344)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 3.05119 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 103.482 | 1 | no | ((-640749.802890959,-1063756.501641,237.600816177918),(-640737.178754876,-1063748.04178041,237.896593198168)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 3.54142 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 103.988 | 1 | no | ((-640751.447523757,-1063760.44424832,237.707063747876),(-640738.765900396,-1063751.96062478,237.922737049344)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 3.55972 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 107.682 | 1 | no | ((-640749.802890959,-1063756.501641,237.400816177918),(-640737.178754876,-1063748.04178041,237.826593198168)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 10.1184 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 108.204 | 1 | no | ((-640751.447523757,-1063760.44424832,237.507063747876),(-640738.765900396,-1063751.96062478,237.852737049344)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 10.1706 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 111.627 | 1 | no | ((-640749.802890959,-1063756.501641,237.078931371937),(-640737.178754876,-1063748.04178041,237.626593198168)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 16.4626 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 110.833 | 1 | no | ((-640751.447523757,-1063760.44424832,237.20642806457),(-640738.765900396,-1063751.96062478,237.652737049344)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 14.3591 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 0.00609013 | 1 | no | ((-640809.913231261,-1063729.63155643,238.489644822261),(-640809.859334349,-1063729.59203568,238.530651787115)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.000020263 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 0.0252045 | 1 | no | ((-640809.947257791,-1063729.704379,238.427635328614),(-640809.859334349,-1063729.59203568,238.490651787087)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.000256456 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 0.047886 | 1 | no | ((-640809.983427725,-1063729.78178883,238.355499252676),(-640809.859334349,-1063729.59203568,238.430651787091)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.000589534 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 0.249745 | 1 | no | ((-640810.157704521,-1063730.15477088,238.14520704484),(-640809.859334349,-1063729.59203568,238.360651787097)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.00442148 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 0.862573 | 1 | no | ((-640810.727494756,-1063731.35304262,237.831093292953),(-640809.859334349,-1063729.59203568,238.160651787117)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 0.0138593 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 0.573324 | 1 | no | ((-640811.4060886,-1063732.92335895,238.107365895451),(-640810.670561653,-1063731.34935195,239.123503188525)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 0.0000267278 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3000.05 | 3000.05 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 0.396386 | 1 | no | ((-640810.421215532,-1063730.71872936,238.282052108314),(-640809.859334349,-1063729.59203568,238.530651787092)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.00668278 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 0.536521 | 1 | no | ((-640810.556345082,-1063730.98675414,237.865701833535),(-640809.936055972,-1063729.75623462,238.365673417915)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.00928277 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3000 | 3000.05 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 1.25248 | 1 | no | ((-640751.455239407,-1063760.4626118,237.913932061565),(-640740.353136878,-1063755.87960055,238.02273714914)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00476976 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 3.5647 | 1 | no | ((-640751.486161313,-1063760.53657449,237.853932061421),(-640740.353136878,-1063755.87959954,237.983167371525)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0610349 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
