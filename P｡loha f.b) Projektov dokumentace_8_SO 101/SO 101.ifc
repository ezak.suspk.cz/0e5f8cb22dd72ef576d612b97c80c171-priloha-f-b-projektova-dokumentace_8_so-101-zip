Properties of the parts of a building model (IFC4X3_ADD2), part 8 of 21

# IfcBuiltElement (2093)
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | Linetype | ColorIndex | Layer | PlotStyleName | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | Skupina elementů | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Tloušťka
vozovka_chodník-podkladní asfaltová vrstva | 5.80658 | 1 | no | ((-640751.519012131,-1063760.61513388,237.783932061425),(-640740.353136878,-1063755.87959848,237.923658872089)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.140335 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 17.1876 | 1 | no | ((-640751.672739309,-1063760.97884461,237.583932061418),(-640740.353136878,-1063755.87959417,237.854488437391)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 1.03636 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 43.5223 | 1 | no | ((-640752.093575246,-1063761.95100051,237.333932061423),(-640740.353136878,-1063755.87959747,237.656930186168)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 2.4925 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 7.91146 | 1 | no | ((-640751.919721277,-1063761.57618541,237.705833078249),(-640740.353136878,-1063755.87959113,238.022737192061)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.345276 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 37.6965 | 1 | no | ((-640752.093582937,-1063761.95099662,237.36464011554),(-640740.421659935,-1063756.04820892,237.857629019931)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 2.31638 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3063.93 | 3075.87 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 0.00608496 | 1 | no | ((-640806.306419282,-1063721.91236395,238.489601261004),(-640806.252566767,-1063721.87286394,238.530608477925)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0000202437 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 0.0251898 | 1 | no | ((-640806.306419282,-1063721.91236395,238.427591767372),(-640806.218540656,-1063721.80004156,238.490608477925)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.000256202 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 0.0478617 | 1 | no | ((-640806.306419282,-1063721.91236395,238.355455691412),(-640806.182371167,-1063721.72263194,238.430608477925)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.000588947 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 0.249669 | 1 | no | ((-640806.306419282,-1063721.91236395,238.145163483628),(-640806.008096516,-1063721.34965089,238.360608477925)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.00441692 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 0.862448 | 1 | no | ((-640806.306419282,-1063721.91236395,237.831040611199),(-640805.483572148,-1063720.13018448,238.160608477925)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 0.0138446 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 0.24455 | 1 | no | ((-640805.450572625,-1063720.1774091,238.107865940165),(-640805.129727671,-1063719.49087494,238.634166833448)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 0.000011354 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3000.05 | 3000.05 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 0.396242 | 1 | no | ((-640806.306419282,-1063721.91236395,238.282008547093),(-640805.744588748,-1063720.78569392,238.530608477934)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.00667541 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 0.536041 | 1 | no | ((-640806.229696714,-1063721.74816457,237.865650279398),(-640805.638393321,-1063720.49647439,238.365630108709)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.00926729 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3000 | 3000.05 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 49.0936 | 1 | no | ((-640766.201554842,-1063742.53220353,236.841970768813),(-640758.02265941,-1063736.81591728,237.880714475375)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 3.16552 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3044.15 | 3051.52 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 167.058 | 1 | no | ((-640747.942114775,-1063752.04110327,235.633105520458),(-640734.431484096,-1063742.09354872,237.745332005387)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 11.7653 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3063.93 | 3075.87 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 1.25394 | 1 | no | ((-640748.158290748,-1063752.55923634,237.730309845939),(-640737.171191193,-1063748.02316002,237.89034281961)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00480937 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 3.55855 | 1 | no | ((-640748.158290611,-1063752.5592368,237.668300340174),(-640737.141172836,-1063747.94904161,237.850342819741)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0608631 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 5.79405 | 1 | no | ((-640748.158290611,-1063752.55923727,237.596164251509),(-640737.109263557,-1063747.87025432,237.79034281961)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.139902 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 17.4906 | 1 | no | ((-640748.158290611,-1063752.55923954,237.385871982459),(-640736.955515778,-1063747.49063528,237.720342819751)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 1.04905 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 56.2287 | 1 | no | ((-640748.158290611,-1063752.5592379,237.01647218014),(-640736.401228168,-1063746.117883,237.520342819739)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 5.30138 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 26.5656 | 1 | no | ((-640748.158290748,-1063752.55924038,237.585416657741),(-640736.781584219,-1063747.06118766,237.89034281961)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 1.0055 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3063.93 | 3075.87 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 40.4308 | 1 | no | ((-640748.098266239,-1063752.41534732,237.178707267877),(-640736.552686826,-1063746.49188361,237.777614132294)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 2.791 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3063.93 | 3075.87 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 59.4889 | 1 | no | ((-642492.955892291,-1062937.49574065,231.87047728412),(-642473.934334052,-1062927.38016261,232.345508268185)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 3.42927 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1136.04 | 1156.5 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 69.815 | 1 | no | ((-642525.412004048,-1062923.38953421,232.033302004066),(-642503.17298242,-1062911.72168869,232.526250457128)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 4.02789 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1100 | 1124.04 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 53.1246 | 1 | no | ((-642493.034645092,-1062937.65897557,232.159746775508),(-642474.073071686,-1062927.66773113,232.510486637401)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 2.73366 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1156.5 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 62.3516 | 1 | no | ((-642525.49075685,-1062923.55276912,232.322571495426),(-642503.311720054,-1062912.00925721,232.691228826347)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 3.21086 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 174.625 | 1 | no | ((-642492.72379156,-1062937.01465372,231.21667020953),(-642472.770326782,-1062924.57936453,232.579775343563)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 11.9759 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1136.04 | 1156.5 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 258.675 | 1 | no | ((-642525.179903317,-1062922.90844727,231.547204642431),(-642501.781151319,-1062907.5235789,233.525428599599)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 18.0729 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1100 | 1124.04 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 87.3583 | 1 | no | ((-642493.034645092,-1062937.65897557,231.708242165397),(-642473.758096364,-1062927.01486583,232.140486637401)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 7.35582 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1156.5 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 102.483 | 1 | no | ((-642525.49075685,-1062923.55276912,231.871066885296),(-642502.996744732,-1062911.35639191,232.321228826347)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 8.63989 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-horní podkladní vrstva | 30.0287 | 1 | no | ((-642493.034645092,-1062937.65897557,232.022901712042),(-642474.343555727,-1062928.2283771,232.340486637401)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 1.80871 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1156.5 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 35.2398 | 1 | no | ((-642525.49075685,-1062923.55276912,232.185726431939),(-642503.582204095,-1062912.56990318,232.521228826348)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 2.12445 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 9.97067 | 1 | no | ((-642493.034645092,-1062937.65897557,232.233193919834),(-642474.522444237,-1062928.59916837,232.410486637403)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.241167 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1156.5 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 11.7071 | 1 | no | ((-642525.49075685,-1062923.55276912,232.396018639742),(-642503.761092605,-1062912.94069445,232.591228826348)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.283267 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 6.12647 | 1 | no | ((-642493.034645092,-1062937.65897557,232.305329995783),(-642474.559571299,-1062928.67612351,232.470486637401)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.104912 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1156.5 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 7.19414 | 1 | no | ((-642525.490756849,-1062923.55276912,232.468154715743),(-642503.798219667,-1062913.01764959,232.651228826344)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.123226 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-obrusná vrstva | 2.16076 | 1 | no | ((-642493.034645092,-1062937.65897557,232.367339489454),(-642474.59449824,-1062928.74851835,232.510486637401)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00828932 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1156.5 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 2.53781 | 1 | no | ((-642525.49075685,-1062923.55276912,232.53016420941),(-642503.833146608,-1062913.09004443,232.691228826347)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00973634 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
zemní práce-zemní krajnice a dosypávky | 0.611297 | 1 | no | ((-642497.397064957,-1062937.85048008,231.972638939762),(-642496.720809121,-1062936.58560607,232.345508268212)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.016009 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1136.04 | 1136.13 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 69.815 | 1 | no | ((-642529.853176714,-1062932.59497767,232.033302004054),(-642507.614155086,-1062920.92713215,232.526250457118)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 4.02789 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1100 | 1124.04 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 0.513921 | 1 | no | ((-642497.258327323,-1062937.56291156,232.261908431151),(-642496.64205632,-1062936.42237116,232.510486637415)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.0127617 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1136.13 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 62.3516 | 1 | no | ((-642529.71443908,-1062932.30740915,232.322571495394),(-642507.535402285,-1062920.76389724,232.691228826331)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 3.21086 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-spodní podkladní vrstva | 1.12336 | 1 | no | ((-642497.573302645,-1062938.21577686,231.810403821038),(-642496.64205632,-1062936.42237116,232.140486637398)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 0.0343396 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1136.13 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 102.483 | 1 | no | ((-642530.029414403,-1062932.96027445,231.871066885342),(-642507.535402285,-1062920.76389724,232.321228826331)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 8.63989 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-horní podkladní vrstva | 0.316127 | 1 | no | ((-642496.987843282,-1062937.0022656,232.125063367685),(-642496.64205632,-1062936.42237116,232.340486637395)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.00844371 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1136.13 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 35.2398 | 1 | no | ((-642529.443955039,-1062931.74676318,232.185726431958),(-642507.535402285,-1062920.76389724,232.521228826331)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 2.12445 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 0.0700061 | 1 | no | ((-642496.808954772,-1062936.63147432,232.335355575477),(-642496.64205632,-1062936.42237116,232.410486637399)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00112585 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1136.13 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 11.7071 | 1 | no | ((-642529.26506653,-1062931.37597191,232.396018639781),(-642507.535402285,-1062920.76389724,232.591228826331)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.283267 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 0.0388058 | 1 | no | ((-642496.77182771,-1062936.55451918,232.407491651426),(-642496.64205632,-1062936.42237116,232.470486637395)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.000489765 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1136.13 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 7.19414 | 1 | no | ((-642529.227939467,-1062931.29901677,232.468154715731),(-642507.535402285,-1062920.76389724,232.651228826334)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.123226 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-obrusná vrstva | 0.0108935 | 1 | no | ((-642496.736900769,-1062936.48212434,232.469501145097),(-642496.64205632,-1062936.42237116,232.510486637448)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0000386974 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1136.13 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 2.53781 | 1 | no | ((-642529.193012527,-1062931.22662193,232.530164209402),(-642507.535402285,-1062920.76389724,232.691228826331)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00973634 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-spodní podkladní vrstva | 47.3383 | 1 | no | ((-642408.045416927,-1062981.38001474,231.350300822099),(-642401.6953884,-1062975.37958825,231.752878887886)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 5.53828 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1234.5 | 1239.5 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 219.136 | 1 | no | ((-642529.184212038,-1062931.20838071,231.929420538515),(-642505.688674691,-1062916.93609144,232.427478826339)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 26.6243 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 47.3383 | 1 | no | ((-642406.198689333,-1062977.55220895,231.350300823262),(-642399.848660805,-1062971.55178246,231.752878888699)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 5.53828 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1234.5 | 1239.5 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 219.136 | 1 | no | ((-642527.337484443,-1062927.38057492,231.929420538524),(-642503.841947097,-1062913.10828565,232.427478826336)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 26.6243 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-horní podkladní vrstva | 46.2138 | 1 | no | ((-642408.045416927,-1062981.38001474,231.621550822295),(-642401.6953884,-1062975.37958825,231.952878887886)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 4.25 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1234.5 | 1239.5 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 215.692 | 1 | no | ((-642529.184212038,-1062931.20838071,232.200670538515),(-642505.688674691,-1062916.93609144,232.627478826336)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 20.4311 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 46.2138 | 1 | no | ((-642406.198689333,-1062977.55220895,231.621550823262),(-642399.848660805,-1062971.55178246,231.952878888701)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 4.25 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1234.5 | 1239.5 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 215.692 | 1 | no | ((-642527.337484444,-1062927.38057492,232.200670538524),(-642503.841947097,-1062913.10828565,232.627478826339)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 20.4311 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 43.8088 | 1 | no | ((-642408.045416927,-1062981.38001474,231.821550822291),(-642401.695388399,-1062975.37958825,232.022878887886)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.4875 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1234.5 | 1239.5 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 208.338 | 1 | no | ((-642529.184212038,-1062931.20838071,232.400670538515),(-642505.688674691,-1062916.93609144,232.697478826336)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 7.15089 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 43.8088 | 1 | no | ((-642406.198689333,-1062977.55220895,231.821550823262),(-642399.848660805,-1062971.55178246,232.022878888698)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.4875 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1234.5 | 1239.5 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 208.338 | 1 | no | ((-642527.337484444,-1062927.38057492,232.400670538524),(-642503.841947097,-1062913.10828565,232.697478826339)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 7.15089 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 43.6238 | 1 | no | ((-642408.045416927,-1062981.38001474,231.891550822292),(-642401.695388399,-1062975.37958825,232.082878887886)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.275 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1234.5 | 1239.5 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 207.772 | 1 | no | ((-642529.184212038,-1062931.20838071,232.470670538515),(-642505.688674691,-1062916.93609144,232.757478826336)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 6.12933 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 43.6238 | 1 | no | ((-642406.198689333,-1062977.55220895,231.891550823262),(-642399.848660805,-1062971.55178246,232.082878888701)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.275 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1234.5 | 1239.5 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 207.772 | 1 | no | ((-642527.337484444,-1062927.38057492,232.470670538524),(-642503.841947097,-1062913.10828565,232.757478826339)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 6.12933 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-obrusná vrstva | 43.2538 | 1 | no | ((-642408.045416927,-1062981.38001474,231.951550822296),(-642401.695388399,-1062975.37958825,232.122878887886)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.85 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1234.5 | 1239.5 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 206.64 | 1 | no | ((-642529.184212038,-1062931.20838071,232.530670538515),(-642505.688674691,-1062916.93609144,232.797478826336)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 4.08622 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 43.2538 | 1 | no | ((-642406.198689333,-1062977.55220895,231.951550823262),(-642399.848660805,-1062971.55178246,232.122878888701)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.85 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1234.5 | 1239.5 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 206.64 | 1 | no | ((-642527.337484444,-1062927.38057492,232.530670538524),(-642503.841947097,-1062913.10828565,232.797478826339)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 4.08622 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1100 | 1124.04 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 389.139 | 1 | no | ((-642401.6953884,-1062997.23615249,231.724343557746),(-642359.048754348,-1062973.72440316,232.097800824225)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 7.701 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1284.8 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 845.434 | 1 | no | ((-642494.881372686,-1062975.37958825,231.976628887893),(-642404.351961739,-1062928.76675957,232.616736637397)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 16.7389 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1234.5 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 389.139 | 1 | no | ((-642403.542115994,-1063001.06395828,231.724343557747),(-642360.895481942,-1062977.55220895,232.09780082326)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 7.701 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1284.8 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 845.434 | 1 | no | ((-642496.72810028,-1062979.20739404,231.976628887069),(-642406.198689333,-1062932.59456536,232.616736637397)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 16.7389 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1234.5 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 391.121 | 1 | no | ((-642401.6953884,-1062997.23615249,231.664343557746),(-642359.048754348,-1062973.72440316,232.057800824223)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 11.5515 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1284.8 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 849.542 | 1 | no | ((-642494.881372686,-1062975.37958825,231.916628887893),(-642404.351961739,-1062928.76675957,232.576736637397)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 25.1083 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1234.5 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 391.121 | 1 | no | ((-642403.542115994,-1063001.06395828,231.664343557747),(-642360.895481942,-1062977.55220895,232.05780082326)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 11.5515 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1284.8 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 849.542 | 1 | no | ((-642496.72810028,-1062979.20739404,231.916628887066),(-642406.198689333,-1062932.59456536,232.576736637397)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 25.1083 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1234.5 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 392.112 | 1 | no | ((-642401.6953884,-1062997.23615249,231.594343557746),(-642359.048754348,-1062973.72440316,231.997800824225)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 13.4767 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1284.8 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 851.597 | 1 | no | ((-642494.881372686,-1062975.37958825,231.846628887893),(-642404.351961739,-1062928.76675957,232.516736637399)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 29.2931 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1234.5 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 392.112 | 1 | no | ((-642403.542115994,-1063001.06395828,231.594343557747),(-642360.895481942,-1062977.55220895,231.99780082326)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 13.4767 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1284.8 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 851.597 | 1 | no | ((-642496.72810028,-1062979.20739404,231.846628887069),(-642406.198689333,-1062932.59456536,232.516736637396)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 29.2931 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1234.5 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 404.995 | 1 | no | ((-642401.6953884,-1062997.23615249,231.394343557746),(-642359.048754348,-1062973.72440316,231.927800824224)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 38.505 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1284.8 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 878.302 | 1 | no | ((-642494.881372686,-1062975.37958825,231.646628887893),(-642404.351961739,-1062928.76675957,232.446736637396)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 83.6945 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1234.5 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 404.995 | 1 | no | ((-642403.542115994,-1063001.06395828,231.394343557747),(-642360.895481942,-1062977.55220895,231.92780082326)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 38.505 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1284.8 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 878.302 | 1 | no | ((-642496.72810028,-1062979.20739404,231.646628887067),(-642406.198689333,-1062932.59456536,232.446736637396)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 83.6945 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1234.5 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 411.03 | 1 | no | ((-642401.6953884,-1062997.23615249,231.123093557747),(-642359.048754348,-1062973.72440316,231.727800824216)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 50.1768 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1284.8 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 890.814 | 1 | no | ((-642494.881372686,-1062975.37958825,231.375378887894),(-642404.351961739,-1062928.76675957,232.246736637396)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 109.064 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1234.5 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 411.03 | 1 | no | ((-642403.542115994,-1063001.06395828,231.123093557747),(-642360.895481942,-1062977.55220895,231.727800823261)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 50.1768 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1284.8 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 890.814 | 1 | no | ((-642496.72810028,-1062979.20739404,231.375378886905),(-642406.198689333,-1062932.59456536,232.246736637396)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 109.064 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.04 | 1234.5 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-zemní krajnice a dosypávky | 85.8814 | 1 | no | ((-642399.78125989,-1062986.17829002,231.308545733176),(-642373.027548955,-1062972.3378062,231.878822188238)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 5.24833 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1239.5 | 1268.54 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 228.919 | 1 | no | ((-642474.491280013,-1062971.41207717,231.479260353446),(-642403.682997062,-1062936.28842778,232.26627710448)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 13.8408 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1156.54 | 1234.5 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 69.443 | 1 | no | ((-642399.848660805,-1062986.34152493,231.597815224572),(-642373.166286589,-1062972.76655248,231.991550823263)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 3.08436 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1268.54 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 189.818 | 1 | no | ((-642474.570032814,-1062971.55178246,231.83122952585),(-642403.889846009,-1062936.5759963,232.407660566734)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 8.80222 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1156.54 | 1234.5 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-spodní podkladní vrstva | 123.651 | 1 | no | ((-642399.848660805,-1062986.34152493,231.146310614453),(-642372.851311266,-1062971.97250942,231.621550823263)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 10.4371 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1268.54 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 330.79 | 1 | no | ((-642474.570032814,-1062971.55178246,231.317025234719),(-642403.506759374,-1062935.923131,232.037660566734)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 28.0235 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1156.54 | 1234.5 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-horní podkladní vrstva | 42.5335 | 1 | no | ((-642399.848660805,-1062986.34152493,231.460970161098),(-642373.43677063,-1062973.18602069,231.821550823262)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 2.56638 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1268.54 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 113.904 | 1 | no | ((-642474.570032814,-1062971.55178246,231.631684781367),(-642404.092218738,-1062937.13664226,232.237660566734)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 6.89067 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1156.54 | 1234.5 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 14.1375 | 1 | no | ((-642399.848660805,-1062986.34152493,231.67126236889),(-642373.615659139,-1062973.55681196,231.891550823262)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.342191 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1268.54 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 37.9191 | 1 | no | ((-642474.570032814,-1062971.55178246,231.841976989146),(-642404.271107247,-1062937.50743354,232.307660566734)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.918778 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1156.54 | 1234.5 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 8.68852 | 1 | no | ((-642399.848660805,-1062986.34152493,231.74339844484),(-642373.652786202,-1062973.6337671,231.951550823262)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.148859 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1268.54 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 23.3113 | 1 | no | ((-642474.570032814,-1062971.55178246,231.914113065107),(-642404.30823431,-1062937.58438868,232.367660566734)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.399683 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1156.54 | 1234.5 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-obrusná vrstva | 3.06555 | 1 | no | ((-642399.848660805,-1062986.34152493,231.805407938511),(-642373.687713142,-1062973.70616194,231.991550823262)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0117617 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1268.54 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 8.22958 | 1 | no | ((-642474.570032814,-1062971.55178246,231.976122558779),(-642404.34316125,-1062937.65678352,232.407660566734)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0315799 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1156.54 | 1234.5 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
zemní práce-rozprostření ornice (ohumusovani) | 303.374 | 1 | no | ((-642399.605918586,-1062985.69720308,229.998255513929),(-642371.829438186,-1062967.89238527,231.846540197298)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 20.4721 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1239.5 | 1268.54 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 708.845 | 1 | no | ((-642474.259179282,-1062971.04863837,230.028703403706),(-642401.569790688,-1062933.8836388,232.233995113527)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 48.4032 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1156.54 | 1234.5 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-zemní krajnice a dosypávky | 134.856 | 1 | no | ((-642404.21108067,-1063002.45055524,231.226975023299),(-642362.809610452,-1062981.54324966,231.83637434501)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 8.45835 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1239.5 | 1284.8 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 292.669 | 1 | no | ((-642497.279003064,-1062980.593991,231.479260353421),(-642408.124169728,-1062936.64256512,232.387122926114)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 18.614 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1136.17 | 1234.5 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 104.025 | 1 | no | ((-642404.072343036,-1063002.02180895,231.578944195707),(-642362.742209537,-1062981.38001474,231.991550823303)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 4.25012 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1284.8 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 220.384 | 1 | no | ((-642497.14026543,-1062980.30642248,231.768529844797),(-642408.045416927,-1062936.4793302,232.509829172171)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 8.51545 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.17 | 1234.5 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-spodní podkladní vrstva | 192.505 | 1 | no | ((-642404.387318359,-1063002.81585202,231.064739904575),(-642362.742209537,-1062981.38001474,231.621550823261)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 16.283 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1284.8 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 415.006 | 1 | no | ((-642497.455240753,-1062980.95928778,231.31702523467),(-642408.045416927,-1062936.4793302,232.139829172171)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 34.9536 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.17 | 1234.5 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-horní podkladní vrstva | 66.2574 | 1 | no | ((-642403.801858995,-1063001.60234075,231.37939945122),(-642362.742209537,-1062981.38001474,231.821550823263)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 4.0038 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1284.8 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 143.618 | 1 | no | ((-642496.869781389,-1062979.74577652,231.631684781358),(-642408.045416927,-1062936.4793302,232.339829172171)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 8.69107 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.17 | 1234.5 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 22.0426 | 1 | no | ((-642403.622970486,-1063001.23154948,231.589691659013),(-642362.742209537,-1062981.38001474,231.891550823268)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.533852 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1284.8 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 47.8204 | 1 | no | ((-642496.69089288,-1062979.37498524,231.841976989149),(-642408.045416927,-1062936.4793302,232.409829172171)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.15884 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.17 | 1234.5 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 13.5492 | 1 | no | ((-642403.585843423,-1063001.15459434,231.661827734962),(-642362.742209537,-1062981.38001474,231.951550823266)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.232234 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1239.5 | 1284.8 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 29.3993 | 1 | no | ((-642496.653765817,-1062979.2980301,231.914113065088),(-642408.045416927,-1062936.4793302,232.469829172171)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.504112 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1136.17 | 1234.5 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
