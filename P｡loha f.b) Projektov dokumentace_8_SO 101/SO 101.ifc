Properties of the parts of a building model (IFC4X3_ADD2), part 19 of 21

# IfcBuiltElement (2093)
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | Linetype | ColorIndex | Layer | PlotStyleName | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | Skupina elementů | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Tloušťka
vozovka_chodník-ložní vrstva | 100.234 | 1 | no | ((-643000.22078433,-1062670.96629452,232.497933228436),(-642987.990274347,-1062662.20596715,232.69135541166)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 3.4298 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 553.5 | 565 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
zemní práce-rozprostření ornice (ohumusovani) | 100.079 | 1 | no | ((-642995.993451261,-1062662.02456838,231.506876732198),(-642984.345490345,-1062653.77124165,232.804865718883)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 6.87506 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 553.5 | 565 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 1.2085 | 1 | no | ((-642996.568960659,-1062663.24189556,232.567426899322),(-642986.208149206,-1062658.34989963,232.62510541166)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00463462 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 553.5 | 565 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 3.7338 | 1 | no | ((-642996.568960659,-1062663.24189556,232.495290823372),(-642986.172490855,-1062658.27274398,232.58510541166)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0704606 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 553.5 | 565 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-zpevnění krajnic | 41.2609 | 1 | no | ((-642996.568960659,-1062663.24189556,232.368505264584),(-642985.49091651,-1062656.79798969,232.62510541166)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 1.79017 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 553.5 | 565 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 78.7969 | 1 | no | ((-643076.161731448,-1062643.42736804,232.302075386194),(-643050.31660904,-1062630.32350422,232.525135919262)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | C30/37 XF4+XD3 | D.1.1.4 | beton | TP 139 | P2 | 128;128;128 | 5.25 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 470.05 | 498.05 | zpevnění krajnic | 451315 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 78.7969 | 1 | no | ((-643047.235363368,-1062657.1118567,232.349858852557),(-643021.39024096,-1062644.00799287,232.572919385625)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | C30/37 XF4+XD3 | D.1.1.4 | beton | TP 139 | P2 | 128;128;128 | 5.25 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 502.05 | 530.05 | zpevnění krajnic | 451315 | I1+S1+E1+Z1+M3+F1
záchytné systémy-svodidlo | 62.0635 | 1 | no | ((-643367.771601857,-1062521.72501152,230.912981530142),(-643306.314408029,-1062492.48050036,232.22581328413)) | ByLayer | 4 | záchytné systémy-svodidlo | Barva_4 |  |  |  |  | P2 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | záchytné systémy | 147.06 | 215.06 | svodidlo | 9113A1 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: svodidlo; Stavební výrobek: ocelové svodidlo N2; Specifikace: TP 203; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 68
záchytné systémy-svodidlo | 433.37 | 1 | no | ((-643415.255015807,-1062662.78854526,230.624703957282),(-642985.972815694,-1062459.32413351,233.38210541166)) | ByLayer | 4 | záchytné systémy-svodidlo | Barva_4 |  |  |  |  | P2 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | záchytné systémy | 89.94 | 565 | svodidlo | 9113A1 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: svodidlo; Stavební výrobek: ocelové svodidlo N2; Specifikace: TP 203; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 475.06
záchytné systémy-svodidlo | 99.7381 | 1 | no | ((-643076.094378106,-1062643.28499608,232.456012886194),(-643050.445970222,-1062630.59694879,233.725135919262)) | ByLayer | 4 | záchytné systémy-svodidlo | Barva_4 |  |  |  |  | P2 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | záchytné systémy | 470.05 | 498.05 | svodidlo | 911FA1 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: svodidlo; Stavební výrobek: betonové oboustranné v. 1,2 m; Specifikace: TP 139; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 28
záchytné systémy-svodidlo | 99.7381 | 1 | no | ((-643047.168010025,-1062656.96948473,232.503796352557),(-643021.519602141,-1062644.28143744,233.772919385625)) | ByLayer | 4 | záchytné systémy-svodidlo | Barva_4 |  |  |  |  | P2 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | záchytné systémy | 502.05 | 530.05 | svodidlo | 911FA1 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: svodidlo; Stavební výrobek: betonové oboustranné v. 1,2 m; Specifikace: TP 139; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 28
záchytné systémy-svodidlo | 31.9342 | 1 | no | ((-643021.637417036,-1062671.49036747,233.019919385625),(-642989.974834561,-1062656.43389494,233.38210541166)) | ByLayer | 4 | záchytné systémy-svodidlo | Barva_4 |  |  |  |  | P2 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | záchytné systémy | 530.05 | 565 | svodidlo | 9113A1 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: svodidlo; Stavební výrobek: ocelové svodidlo N2; Specifikace: TP 203; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 34.95
vozovka_chodník-zpevnění krajnic | 638.267 | 1 | no | ((-643290.972284929,-1062631.45344047,231.398571225877),(-643075.62718111,-1062528.75148265,232.483325386194)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 28.338 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 232.45 | 470.05 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
založení-patka _ pás | 22.6011 | 1 | no | ((-643050.851159378,-1062645.13792912,231.293885919262),(-643046.700898558,-1062642.29761258,232.531108852557)) | ByLayer | 6 | založení-patka _ pás | Barva_6 | nerelevantni | D.1.1.4 | beton | nerelevantni | P10 | 255;0;255 | 5.99904 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | založení | 498.05 | 502.05 | patka / pás | 27231A | I1+S1;4+E1+Z1+M3+F1 | CZ_S4 - Specifikace: nerelevantni; Beton: C20/25 XF3; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.1.4; Návrhová životnost: 25
založení-patka _ pás | 22.3192 | 2 | no | ((-643050.778347038,-1062644.97931421,232.498273003148),(-643046.830174212,-1062642.57082528,234.023544680063)) | ByLayer | 6 | založení-patka _ pás | Barva_6 | nerelevantni | D.1.1.4 | beton | nerelevantni | P10 | 255;0;255 | 3.06 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | založení | 498.05 | 502.05 | patka / pás | 272325 | I1+S1;4+E1+Z1+M3+F1 | CZ_S4 - Specifikace: nerelevantni; Beton: C30/37 XF4 XD3; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.1.4; Návrhová životnost: 25
záchytné systémy-svodidlo | 213.501 | 1 | no | ((-643287.37877946,-1062630.84598674,231.362181965225),(-643075.841001245,-1062530.66418938,233.240325386194)) | ByLayer | 4 | záchytné systémy-svodidlo | Barva_4 |  |  |  |  | P2 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | záchytné systémy | 236.06 | 470.05 | svodidlo | 9113A1 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: svodidlo; Stavební výrobek: ocelové svodidlo N2; Specifikace: TP 203; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 233.99
dopravní značení-svislé dopravní značení | 21.62 | 2 | no | ((-643049.22891802,-1062644.23015087,232.51249738591),(-643046.593544716,-1062639.4752037,239.112497385537)) | ByLayer | 256 | dopravní značení-svislé dopravní značení | ByLayer |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 499.75 | 500.35 | svislé dopravní značení | 426841 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: poloportál; Specifikace: DZ do 10 m2; Podrobná specifikace: ŘSD R 1, R 55, R118; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 20.52 | 2 | no | ((-643048.792238262,-1062643.09099971,237.812497385312),(-643047.04551922,-1062639.45809809,240.312497385312)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 499.76 | 499.8 | svislé dopravní značení | 914526 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IS9b; Specifikace: velikost velkoplošná, RA2; Podrobná specifikace: montáž na poloportál; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
vozovka_chodník-zpevnění krajnic | 8.89448 | 1 | no | ((-643304.023907695,-1062525.61659229,231.265585033616),(-643301.453873408,-1062522.59803145,231.553836610299)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.399844 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 218.31 | 221.13 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 14.6042 | 1 | no | ((-643304.844588849,-1062527.57670979,230.690487994231),(-643301.469056834,-1062524.40305589,231.564839597632)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 0.594997 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 218.31 | 221.31 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
propustky-zpevnění dlažbou | 12.3189 | 2 | no | ((-643386.534564687,-1062473.08067527,229.86),(-643382.07185615,-1062469.59941672,230.89)) | ByLayer | 8 | propustky-zpevnění dlažbou | Barva_8 | nerelevantni | D.1.1.4 | lomový kámen, spárováno MC | nerelevantni | P50 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 120.98 | 125 | zpevnění dlažbou | 465512 | I1+S1+E1+Z1+M2+F1 | CZ_M2 - Způsob stanovení plochy: 3D plocha TIN povrchu; Plocha: 4.3856
propustky-lože | 10.8006 | 1 | no | ((-643386.534564687,-1062473.08067527,229.76),(-643382.07185615,-1062469.59941672,230.69)) | ByLayer | 16 | propustky-lože | Barva_16 | nerelevantni | D.1.1.4 | beton | nerelevantni | P50 | 128;0;0 | 0.37649 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 120.98 | 125 | lože | 45131A | I1+S1;4+E1+Z1+M3+F1 | CZ_S4 - Specifikace: nerelevantni; Beton: C20/25nXF3; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.1.4; Návrhová životnost: 25
vozovka_chodník-krytová vrstva nezpevněných vozovek | 8.88609 | 1 | no | ((-643385.625990921,-1062472.65164506,230.41),(-643382.980480077,-1062470.00611628,230.89)) | ByLayer | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | nerelevantni | D.1.1.4 | Recyklovaný materiál | TP 210 | P2 | 125;75;0 | 0.397798 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 121.98 | 124 | krytová vrstva nezpevněných vozovek | 56360 | I1+S1+E1+Z1+M3;2&6+F1 | 0.1
zemní práce-rozprostření ornice (ohumusovani) | 507.432 | 1 | no | ((-643383.00223309,-1062514.8197233,229.919534139171),(-643294.644766875,-1062471.23384862,231.294811856555)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 32.9083 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 125 | 222 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
propustky-zásypy a obsypy | 6.71287 | 2 | no | ((-643385.514124452,-1062471.93740716,230.050000311803),(-643382.990534589,-1062470.3133115,230.618141780619)) | ByLayer | 40 | propustky-zásypy a obsypy | Barva_40 | nerelevantni | D.1.1.4 | zemina | ČSN 73 6133 | P50 | 255;165;0 | 0.283126 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 121.71 | 124.31 | zásypy a obsypy | 17511 | I1+S1;3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
propustky-podkladní vrstva | 4.48401 | 2 | no | ((-643385.702686095,-1062472.01885368,229.900000311898),(-643382.735397548,-1062470.18978896,230.11443681999)) | ByLayer | 2 | propustky-podkladní vrstva | Barva_2 | nerelevantni | D.1.1.4 | štěrkodrť fr. 0/32 | nerelevantni | P50 | 255;255;0 | 0.277523 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 121.5 | 124.5 | podkladní vrstva | 45152 | I1+S1+E1+Z1+M3+F1
propustky-propust | 7.17571 | 2 | no | ((-643385.666945071,-1062471.9386173,230.030000311888),(-643382.777635655,-1062470.26841594,230.487662451063)) | ByLayer | 8 | propustky-propust | Barva_8 | nerelevantni | D.1.1.4 | PP | nerelevantni | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 121.5 | 124.5 | propust | 87446 | I1+S1;2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: propustek; Stavební výrobek: PP SN8 DN400; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 3
zemní práce-rozprostření ornice (ohumusovani) | 661.051 | 1 | no | ((-643502.061458149,-1062492.43474694,229.30814419436),(-643375.635498333,-1062431.02742836,230.875707963981)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 44.5664 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 0 | 138.96 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 619.297 | 1 | no | ((-643501.385709457,-1062490.51684038,230.149749025337),(-643374.835913954,-1062429.33317506,231.12512359715)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 28.2455 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0 | 138.96 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 15.1383 | 1 | no | ((-643375.767346515,-1062493.9490821,230.851122622111),(-643367.60959284,-1062488.55578072,231.165501164357)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.660212 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 138.96 | 146.96 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-krytová vrstva nezpevněných vozovek | 40.1229 | 1 | no | ((-643374.858486012,-1062494.96227301,230.498968439737),(-643367.60959284,-1062488.55578072,231.165501164332)) | ByLayer | 36 | vozovka_chodník-krytová vrstva nezpevněných vozovek | Barva_36 | nerelevantni | D.1.1.4 | Recyklovaný materiál | TP 210 | P2 | 125;75;0 | 1.87684 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 138.96 | 146.96 | krytová vrstva nezpevněných vozovek | 56360 | I1+S1+E1+Z1+M3;2&6+F1 | 0.1
zemní práce-rozprostření ornice (ohumusovani) | 22.0875 | 1 | no | ((-643376.678183997,-1062495.60377964,229.99),(-643368.469143701,-1062490.36175805,231.01)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 1.32042 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 138.96 | 146.96 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
dopravní značení-svislé dopravní značení | 0.129591 | 2 | yes | ((-643496.708359948,-1062421.19358031,230.383644358052),(-643496.658359948,-1062421.14358031,231.183644358052)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 0.07 | 0.07 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nerelevantni; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.129591 | 2 | yes | ((-643500.712263968,-1062429.80777992,230.384184280206),(-643500.662263968,-1062429.75777992,231.184184280206)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 0.02 | 0.02 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nerelevantni; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.129591 | 2 | yes | ((-643451.311049573,-1062442.30112569,230.63600415305),(-643451.261049573,-1062442.25112569,231.43600415305)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 50.07 | 50.07 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nerelevantni; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.129591 | 2 | yes | ((-643455.503946237,-1062450.82577334,230.636144981848),(-643455.453946237,-1062450.77577334,231.436144981848)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 49.94 | 49.94 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nerelevantni; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.129591 | 2 | yes | ((-643410.339439273,-1062472.27728403,230.888504776842),(-643410.289439272,-1062472.22728403,231.688504776842)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 99.94 | 99.94 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nerelevantni; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643406.146542608,-1062463.75263638,231.688363948039),(-643406.096542608,-1062463.70263638,231.988363948039)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 100.07 | 100.07 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643360.982035643,-1062485.20414706,231.940723743046),(-643360.932035643,-1062485.15414706,232.240723743046)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 150.07 | 150.07 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643365.174932308,-1062493.72879471,231.940864571815),(-643365.124932308,-1062493.67879471,232.240864571815)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 149.94 | 149.94 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643315.817528679,-1062506.65565774,232.193083538019),(-643315.767528679,-1062506.60565774,232.493083538019)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 200.07 | 200.07 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643320.010425343,-1062515.18030539,232.193224366821),(-643319.960425343,-1062515.13030539,232.493224366821)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 199.94 | 199.94 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643270.653021714,-1062528.10716843,232.445443333029),(-643270.603021714,-1062528.05716843,232.745443333029)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 250.07 | 250.07 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643274.845918379,-1062536.63181608,232.445584161791),(-643274.795918379,-1062536.58181608,232.745584161791)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 249.94 | 249.94 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643225.473406333,-1062549.50973225,232.697803128008),(-643225.423406332,-1062549.45973225,232.997803128008)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 300.07 | 300.07 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643229.653185472,-1062558.04081931,232.697943956783),(-643229.603185472,-1062557.99081931,232.997943956783)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 299.94 | 299.94 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643180.275956207,-1062570.89174577,232.949831192922),(-643180.225956207,-1062570.84174577,233.249831192922)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 350.07 | 350.07 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643184.455735347,-1062579.42283283,232.950000711661),(-643184.405735347,-1062579.37283283,233.250000711661)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 349.94 | 349.94 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643135.078506081,-1062592.27375929,233.130760066207),(-643135.028506081,-1062592.22375929,233.430760066207)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 400.07 | 400.07 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643139.258285221,-1062600.80484635,233.131241954941),(-643139.208285221,-1062600.75484635,233.431241954941)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 399.94 | 399.94 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643089.881055956,-1062613.65577281,233.213096690655),(-643089.831055956,-1062613.60577281,233.513096690655)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 450.07 | 450.07 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643094.060835096,-1062622.18685987,233.213699786257),(-643094.010835096,-1062622.13685987,233.513699786257)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 449.94 | 449.94 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643044.68360583,-1062635.03778633,233.287758356846),(-643044.63360583,-1062634.98778633,233.587758356846)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 500.07 | 500.07 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.0510509 | 2 | yes | ((-643048.86338497,-1062643.56887339,233.315562884795),(-643048.81338497,-1062643.51887339,233.615562884795)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 499.94 | 499.94 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek Z11 a,b; Specifikace: nástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
vozovka_chodník-obrusná vrstva | 0.0024 | 2 | no | ((-642988.010274347,-1062667.10409504,232.69135541166),(-642987.990274347,-1062667.08409504,232.71135541166)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.000008 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 564.97 | 565 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 0.0024 | 2 | no | ((-642988.010274347,-1062667.10409504,232.62135541166),(-642987.990274347,-1062667.08409504,232.64135541166)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.000008 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 564.97 | 565 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-zpevnění krajnic | 113.089 | 1 | no | ((-643028.016620314,-1062658.36818837,232.295968708766),(-642995.924521188,-1062641.636029,232.607933228436)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 5.12662 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 518.7 | 553.5 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 63.1375 | 1 | no | ((-643021.924791298,-1062667.1725044,232.374335478649),(-643000.22078433,-1062655.98192044,232.607933228436)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 2.79348 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 530.05 | 553.5 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 31.0387 | 1 | no | ((-643000.757817223,-1062672.10223554,232.407933228436),(-642989.763947138,-1062666.04374593,232.62510541166)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 1.37851 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 553.5 | 565 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-sanace | 2415.8 | 1 | no | ((-643501.40836995,-1062643.10008739,229.933219998883),(-643027.064945587,-1062429.67896623,232.420436759516)) | ByLayer | 40 | zemní práce-sanace | Barva_40 | nerelevantni | D.1.1.4 | ŠD fr. 0/63 | nerelevantni | P100 | 255;165;0 | 257.254 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 0 | 518.7 | sanace | 17180 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 31.3173 | 1 | no | ((-643299.83812016,-1062651.14580136,231.50372116064),(-643031.651562613,-1062524.18115294,232.555968708766)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.120185 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 222 | 518.7 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 96.5187 | 1 | no | ((-643299.874777804,-1062651.22303751,231.43158508469),(-643031.651562613,-1062524.18115294,232.515968708766)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.82719 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 222 | 518.7 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-obrusná vrstva | 3.67286 | 1 | no | ((-643031.660223681,-1062666.06203468,232.515462379652),(-643000.22078433,-1062651.12749353,232.607933228436)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0140924 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 518.7 | 553.5 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 11.3282 | 1 | no | ((-643031.696762565,-1062666.13919032,232.443326303702),(-643000.22078433,-1062651.12749353,232.567933228436)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.214248 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 518.7 | 553.5 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-obrusná vrstva | 1.22069 | 1 | no | ((-643000.229485622,-1062670.98469964,232.567426899322),(-642989.763947138,-1062666.04374593,232.62510541166)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00468177 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 553.5 | 565 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 3.77172 | 1 | no | ((-643000.2661942,-1062671.06234624,232.495290823372),(-642989.763947138,-1062666.04374593,232.58510541166)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0711776 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 553.5 | 565 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-obrusná vrstva | 3.67483 | 1 | no | ((-643028.016620314,-1062658.36818837,232.515462379652),(-642996.560259367,-1062643.42561918,232.607933228436)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0141 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 518.7 | 553.5 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 11.3344 | 1 | no | ((-643028.016620314,-1062658.36818837,232.443326303702),(-642996.523550789,-1062643.34838303,232.567933228436)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.214365 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 518.7 | 553.5 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
trasa-průjezdní a průchozí prostor | 0.06 | 2 | yes | ((-643498.76057913,-1062425.51928675,230.54),(-643498.66057913,-1062425.41928675,230.64)) | ByLayer | 9 | trasa-průjezdní a průchozí prostor | Barva_9 |  |  |  |  | P2 | 191;191;191 | CZ_I3 - Fáze projektu: PDPS; Označení položky: nerelevantni; Název (trasy): Silnice II/322; Staničení od: 0.02; Staničení do: 0.07; Označení elementu: průjezdní a průchozí prostor; Označení průjezdného profilu: nerelevantni; Klasifikační systém: nerelevantni; Označení šablony vlastností: I3+E1+Z1+F1
vozovka_chodník-obrusná vrstva | 822.156 | 1 | no | ((-639437.066774314,-1063501.20665954,230.13),(-639392.807042058,-1063463.86403841,230.630270374255)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 16.2865 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.43679 | 4.477 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
dopravní značení-svislé dopravní značení-sloupky modre | 0.109956 | 2 | yes | ((-640728.604105168,-1063755.48253955,238.169456510055),(-640728.504105168,-1063755.38253955,238.469456510055)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky modre | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3085.05 | 3085.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11e,f; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-rozprostření ornice (ohumusovani) | 308.202 | 2 | no | ((-641624.005427163,-1063358.37375992,230.402201185279),(-641580.310220422,-1063336.31845836,231.586722197812)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 20.6464 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2097 | 2143.47 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-násyp | 5391.97 | 1 | no | ((-642687.335743933,-1062925.26535932,229.016144040819),(-642522.796411154,-1062817.6404112,233.882348714748)) | ByLayer | 256 | zemní práce-násyp | ByLayer | vhodná, podmínečně vhodná | D1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 3160.82 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 926.04 | 1100 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 9516.59 | 1 | no | ((-642838.628175417,-1062839.30881638,229.289394493373),(-642673.673747175,-1062716.43572371,232.935125608375)) | ByLayer | 256 | zemní práce-násyp | ByLayer | vhodná, podmínečně vhodná | D1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 5670.52 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 731.19 | 919.96 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 360.324 | 1 | no | ((-642531.355945584,-1062946.80545734,230.2727643456),(-642478.451387121,-1062907.5235789,233.357723434203)) | ByLayer | 256 | zemní práce-násyp | ByLayer | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 50.4422 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1100 | 1150 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 953.346 | 1 | no | ((-642361.027250346,-1063112.25849409,229.417457803891),(-642137.186681234,-1062992.54439527,231.756829947089)) | ByLayer | 256 | zemní práce-násyp | ByLayer | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 144.043 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1290 | 1529.66 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-aktivní zóna | 13657.5 | 1 | no | ((-639393.289269937,-1063541.3820161,227.923110066091),(-638910.690860222,-1063489.41105986,229.988250749054)) | ByLayer | 16 | zemní práce-aktivní zóna | Barva_16 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 128;0;0 | 3288.11 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.477 | 4.96 | aktivní zóna | 215663 | I1+S1+E1+Z1+M3+F1
zemní práce-aktivní zóna | 20393.6 | 1 | no | ((-642530.423852659,-1063747.65415633,230.061025704597),(-640770.109925715,-1062917.7151186,238.933558245177)) | ByLayer | 256 | zemní práce-aktivní zóna | ByLayer | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 128;0;0 | 4939.08 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1100 | 3039.16 | aktivní zóna | 215663 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 154.552 | 1 | no | ((-640055.456420409,-1063686.50828557,229.2),(-640042.977927878,-1063675.43651592,233.661181457936)) | ByLayer | 256 | zemní práce-rozprostření ornice (ohumusovani) | ByLayer | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 10.4264 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.78967 | 3.79967 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 929.193 | 1 | no | ((-640608.3534129,-1063817.62034691,231.462326564407),(-640566.507186212,-1063800.9895873,236.78301459177)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 68.0325 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.215 | 3.2516 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 104.343 | 2 | no | ((-640571.404190853,-1063818.16846478,231.456176203382),(-640564.489823737,-1063807.35922145,236.669786584979)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 7.14562 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.25163 | 3.25756 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 12362.3 | 1 | no | ((-640556.808181928,-1063826.09311208,229.418150121838),(-640077.311724347,-1063709.37705474,236.532342564349)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 600.466 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.2687 | 3.7547 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 103.734 | 1 | no | ((-640072.603516032,-1063694.38911227,229.919031636735),(-640066.100807072,-1063684.08731336,233.790035799212)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 7.375 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.7712 | 3.77471 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 73.9012 | 2 | no | ((-642363.204325266,-1063015.81226735,231.359165177819),(-642334.450654443,-1063001.06395828,231.764343557747)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 3.16667 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1284.8 | 1316.12 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 424.582 | 2 | no | ((-642366.091916563,-1063019.83879489,229.778999700002),(-642334.761507974,-1063001.56710237,231.619332931761)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 29.6293 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1284.8 | 1316.12 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 110.199 | 2 | no | ((-640560.442938126,-1063819.70077463,231.232596587726),(-640554.128415443,-1063808.44524694,236.532342564349)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 7.59134 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.26244 | 3.26866 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 1812.39 | 1 | no | ((-640556.374578044,-1063813.253813,233.832516820223),(-640079.665405505,-1063708.53353578,236.797058508648)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 113.295 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.2657 | 3.7552 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 17.3475 | 1 | no | ((-640066.739193136,-1063704.83949916,233.736276429359),(-640061.820872799,-1063701.5242834,234.050336555253)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 1.0585 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.7705 | 3.78371 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 1976.49 | 1 | no | ((-640604.63568735,-1063802.99733843,233.83250666604),(-640083.412128912,-1063698.98703468,236.836930270349)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 123.86 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.215 | 3.7552 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-kryt z dlažebních dílců | 224.654 | 2 | yes | ((-642358.58618162,-1063078.47162089,231.31447064549),(-642180.209209188,-1062992.68425185,231.994187366655)) | ByLayer | 9 | vozovka_chodník-kryt z dlažebních dílců | Barva_9 | nerelevantni | D1.1.4 | bet. dlažba tl. 80 mm v loži HDK | TP 192 | P2 | 191;191;191 | 7.697 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1284.84 | 1482.84 | kryt z dlažebních dílců | 582612 | I1+S1+E1+Z1+M3;2&6+F1 | 0.08
vozovka_chodník-ložní vrstva | 206.193 | 2 | yes | ((-642358.58618162,-1063078.47162089,231.275720645473),(-642180.209209188,-1062992.68425185,231.914187366655)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | lože HDK | TP 192 | P2 | 128;128;128 | 3.788 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1284.84 | 1482.84 | ložní vrstva | nerelevantni | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-spodní podkladní vrstva | 272.835 | 2 | yes | ((-642358.569886965,-1063078.43765325,231.029803978828),(-642180.209209188,-1062992.59418564,231.874187366656)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 17.3575 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1284.84 | 1482.84 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
odvodnění-zpevněné příkopy a odvodňovací žlaby | 30.4514 | 2 | no | ((-642259.570836728,-1063051.81100689,231.109599770045),(-642237.777341033,-1063040.95120784,231.333760708724)) | ByLayer | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 |  |  |  |  | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 1395.25 | 1419.75 | zpevněné příkopy a odvodňovací žlaby | 935812 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: rigol; Stavební výrobek: rigol š. 50 cm v bet. loži C20/25nXF3; Specifikace: žulové kostky drobné; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 24.5
odvodnění-zpevněné příkopy a odvodňovací žlaby | 31.67 | 2 | no | ((-642282.087341392,-1063041.18427587,231.009564616328),(-642259.803904751,-1063030.08810435,231.210885129685)) | ByLayer | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 |  |  |  |  | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 1370.25 | 1394.75 | zpevněné příkopy a odvodňovací žlaby | nerelevantni | nerelevantni | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: rigol; Stavební výrobek: lože; Specifikace: C20/25nXF3; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 24.5
odvodnění-zpevněné příkopy a odvodňovací žlaby | 109.528 | 1 | no | ((-642359.048754348,-1063030.32117237,231.073267239723),(-642282.320409415,-1062992.9580166,231.639343557747)) | ByLayer | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 |  |  |  |  | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 1284.84 | 1369.75 | zpevněné příkopy a odvodňovací žlaby | nerelevantni | nerelevantni | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: rigol; Stavební výrobek: lože; Specifikace: C20/25nXF3; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 84.91
odvodnění-zpevněné příkopy a odvodňovací žlaby | 30.9693 | 1 | no | ((-642259.570836728,-1063051.81100689,231.009599770044),(-642237.777341033,-1063040.95120784,231.208760708716)) | ByLayer | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 |  |  |  |  | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 1395.25 | 1419.75 | zpevněné příkopy a odvodňovací žlaby | nerelevantni | nerelevantni | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: rigol; Stavební výrobek: lože; Specifikace: C20/25nXF3; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 24.5
odvodnění-zpevněné příkopy a odvodňovací žlaby | 81.4009 | 1 | no | ((-642237.619354179,-1063079.06039345,231.069544012461),(-642180.3794898,-1063051.43689697,231.740790956065)) | ByLayer | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 |  |  |  |  | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 1420.25 | 1482.84 | zpevněné příkopy a odvodňovací žlaby | nerelevantni | nerelevantni | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: rigol; Stavební výrobek: lože; Specifikace: C20/25nXF3; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 62.59
odvodnění-zpevněné příkopy a odvodňovací žlaby | 107.665 | 1 | no | ((-642359.048754348,-1063030.32117237,231.17326723972),(-642282.320409415,-1062992.9580166,231.764343557747)) | ByLayer | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 |  |  |  |  | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 1284.84 | 1369.75 | zpevněné příkopy a odvodňovací žlaby | 935812 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: rigol; Stavební výrobek: rigol š. 50 cm v bet. loži C20/25nXF3; Specifikace: žulové kostky drobné; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 84.91
odvodnění-zpevněné příkopy a odvodňovací žlaby | 31.14 | 1 | no | ((-642282.087341392,-1063041.18427587,231.10956461632),(-642259.803904751,-1063030.08810435,231.335885129671)) | ByLayer | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 |  |  |  |  | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 1370.25 | 1394.75 | zpevněné příkopy a odvodňovací žlaby | 935812 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: rigol; Stavební výrobek: rigol š. 50 cm v bet. loži C20/25nXF3; Specifikace: žulové kostky drobné; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 24.5
odvodnění-zpevněné příkopy a odvodňovací žlaby | 80.0117 | 1 | no | ((-642237.619354179,-1063079.06039345,231.171162726654),(-642180.3794898,-1063051.43689697,231.865790956065)) | ByLayer | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 |  |  |  |  | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 1420.25 | 1482.84 | zpevněné příkopy a odvodňovací žlaby | 935812 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: rigol; Stavební výrobek: rigol š. 50 cm v bet. loži C20/25nXF3; Specifikace: žulové kostky drobné; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 62.59

# IfcGeographicElement (125)
In: UnknownName
PredefinedType: TERRAIN
Properties - AutoRebuild: no; HasSnapshot: no; IsOutOfDate: no; IsSnapshotOutOfDate: no; IsVolumeSurface: no; Lock: no; DisplayName: Povrch TIN; IsReferenceStale: no; IsReferenceSubObject: no; IsUsed: no; ShowToolTip: yes; CloneMeForDragging: no; ForceAnnoAllVisible: yes; HasSaveVersionOverride: no; IsCancelling: no; IsErased: no; IsEraseStatusToggled: no; IsModified: no; IsModifiedGraphics: no; IsModifiedXData: no; IsNewObject: no; IsNotifyEnabled: no; IsNotifying: no; IsObjectIdsInFlux: no; IsPersistent: yes; IsReadEnabled: yes; IsReallyClosing: no; IsTransactionResident: yes; IsUndoing: no; IsWriteEnabled: yes; AutoDelete: no; IsDisposed: no
