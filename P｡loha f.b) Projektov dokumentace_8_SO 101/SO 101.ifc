Properties of the parts of a building model (IFC4X3_ADD2), part 21 of 21

# IfcGeographicElement (125)
Name | FingerPrint | IsReferenceObject = IsReferenceValid | Name | StyleName | Bounds | Layer | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Textura / barva | Skupina přesnosti | Description = Properties, Description | Typ stavebního výrobku | Stavební výrobek | Specifikace | Podrobná specifikace | CZ_S2, Reference | Výrobce = Kategorie stavebního výrobku | Délka | Způsob stanovení délky
dopravní značení-vodorovné dopravní značení-V2b 1.5-1.5-0.25 (2) plast | -1523149778 | no | dopravní značení-vodorovné dopravní značení-V2b 1.5-1.5-0.25 (2) plast | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4410 | 4440 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 1,5/1,5/0,25 | plast | TP 133 | D1.1.6 | nerelevantni | 58 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 1.5-1.5-0.25 (3) plast | -780818796 | no | dopravní značení-vodorovné dopravní značení-V2b 1.5-1.5-0.25 (3) plast | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4495 | 4630 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 1,5/1,5/0,25 | plast | TP 133 | D1.1.6 | nerelevantni | 133.5 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V9c barva | -1975923972 | yes | dopravní značení-vodorovné dopravní značení-V9c barva | vdz | ((-643090.285869659,-1063021.43939238,232.52510541166),(-642425.164863744,-1062561.87876633,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 841.97 | 962.31 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V9c | barva | TP 133 | D1.1.6 | nerelevantni | 120.34 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V9a barva | 45824801 | no | dopravní značení-vodorovné dopravní značení-V9a barva | vdz | ((-643090.285869659,-1063926.09311208,227.267351217847),(-638810.17266082,-1062561.87876633,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 625.89 | 4610 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V9a | barva | TP 133 | D1.1.6 | nerelevantni | 5 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V9c plast | -1975923972 | yes | dopravní značení-vodorovné dopravní značení-V9c plast | vdz | ((-643090.285869659,-1063021.43939238,232.52510541166),(-642425.164863744,-1062561.87876633,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 841.97 | 962.31 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V9c | barva | TP 133 | D1.1.6 | nerelevantni | 120.34 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V9a plast | 453580988 | no | dopravní značení-vodorovné dopravní značení-V9a plast | vdz | ((-643090.285869659,-1063638.26887356,229.927331253639),(-639162.855435194,-1062561.87876633,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 625.89 | 4610 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V9a | plast | TP 133 | D1.1.6 | nerelevantni | 5 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V13 barva | -1830114656 | no | dopravní značení-vodorovné dopravní značení-V13 barva | vdz | ((-643090.285869659,-1063926.09311208,227.307351217847),(-638810.17266082,-1062561.87876633,237.134529495381)) | dopravní značení-vodorovné dopravní značení | 590.14 | 4535 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V13 | barva | TP 133 | D.1.1.6 | nerelevantni | 0.5 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V13 plast | 513366407 | no | dopravní značení-vodorovné dopravní značení-V13 plast | vdz | ((-643090.285869659,-1063659.35076773,230.356761459771),(-639234.90770957,-1062561.87876633,233.820653447312)) | dopravní značení-vodorovné dopravní značení | 590.14 | 4535 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V13 | plast | TP 133 | D.1.1.6 | nerelevantni | 0.5 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V5 barva | -137620236 | yes | dopravní značení-vodorovné dopravní značení-V5 barva | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4.42545 | 4.42595 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V5 | barvou | TP 133 | D.1.1.6 | nerelevantni | 3.25 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V5 plast | -137620236 | yes | dopravní značení-vodorovné dopravní značení-V5 plast | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4.42545 | 4.42595 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V5 | barvou | TP 133 | D.1.1.6 | nerelevantni | 0.5 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V3 (2) | 547706376 | yes | dopravní značení-vodorovné dopravní značení-V3 (2) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 3.21306 | 3.23999 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V3 | barvou | TP 133 | D.1.1.6 | nerelevantni | 26.93 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V3 (1) | 1165115371 | yes | dopravní značení-vodorovné dopravní značení-V3 (1) | vdz | ((-642629.510105143,-1063893.70670127,231.23447064549),(-640538.31178625,-1062812.43279051,239.569808245177)) | dopravní značení-vodorovné dopravní značení | 2280 | 3179.75 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V3 | barvou | TP 133 | D.1.1.6 | nerelevantni | 899.75 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V3 (2) plast | 547706376 | yes | dopravní značení-vodorovné dopravní značení-V3 (2) plast | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 3.21306 | 3.23999 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V3 | barvou | TP 133 | D.1.1.6 | nerelevantni | 26.93 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V3 (1) plast | 1165115371 | yes | dopravní značení-vodorovné dopravní značení-V3 (1) plast | vdz | ((-642629.510105143,-1063893.70670127,231.23447064549),(-640538.31178625,-1062812.43279051,239.569808245177)) | dopravní značení-vodorovné dopravní značení | 2280 | 3179.75 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V3 | barvou | TP 133 | D.1.1.6 | nerelevantni | 899.75 | Délka 3D křivky
