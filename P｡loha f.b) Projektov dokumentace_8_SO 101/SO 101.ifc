Properties of the parts of a building model (IFC4X3_ADD2), part 18 of 21

# IfcBuiltElement (2093)
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | Linetype | ColorIndex | Layer | PlotStyleName | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | Skupina elementů | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Tloušťka
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642789.73001824,-1062716.71264556,233.4),(-642789.65180683,-1062716.63443415,235.750526120048)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 778.25 | 778.25 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642780.726709676,-1062725.96490232,233),(-642780.648498266,-1062725.88669091,235.350526120048)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 786.55 | 786.55 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642771.486636311,-1062746.7661455,233),(-642771.408424901,-1062746.68793409,235.350526120048)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 800.5 | 800.5 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642765.942472565,-1062736.07013271,233),(-642765.864261156,-1062735.9919213,235.350526120048)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 794.24 | 794.24 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642755.144516611,-1062734.9822519,233.1),(-642755.066305202,-1062734.90404049,235.450526120048)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 798.92 | 798.92 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.746734 | 2 | yes | ((-642751.687218808,-1062728.94234636,233),(-642751.609007398,-1062728.86413495,236)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 795.55 | 795.55 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.746734 | 2 | yes | ((-642755.008391045,-1062752.98352138,233),(-642754.930179635,-1062752.90530997,236)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 817.14 | 817.14 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642748.826508751,-1062772.50275664,233.6),(-642748.748297341,-1062772.42454523,235.950526120048)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 834.91 | 834.91 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642710.405606582,-1062794.46219744,233.2),(-642710.327395172,-1062794.38398603,235.550526120048)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 878.55 | 878.55 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642629.295334212,-1062853.3032096,232.908047602577),(-642629.217122803,-1062853.22499819,235.258573722625)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 979.53 | 979.53 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-rozprostření ornice (ohumusovani) | 61.4719 | 2 | yes | ((-642678.385776835,-1062823.96648793,231.399712905251),(-642670.913273914,-1062816.79291104,233.47)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 4.02222 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 919.96 | 926.04 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 68.3655 | 1 | no | ((-642690.108235219,-1062839.92106501,230.95),(-642682.324778252,-1062832.45864466,233.38)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 4.4024 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 919.96 | 926.04 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-násyp | 589.038 | 2 | yes | ((-642689.900761017,-1062839.63760643,229.23),(-642671.119939252,-1062817.074584,233.254554069057)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 301.484 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 919.96 | 926.04 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 16.9215 | 2 | yes | ((-642675.465269843,-1062819.93068668,230.153070579352),(-642669.16072791,-1062814.17356466,231.339256737017)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 2.17443 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 919.96 | 926.04 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 20.238 | 2 | yes | ((-642692.335749511,-1062842.9321192,229.527816305613),(-642685.365860357,-1062836.60466362,230.879889374837)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 2.16007 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 919.96 | 926.04 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 14.8879 | 2 | yes | ((-642675.522946266,-1062819.93213877,230.2),(-642669.158274841,-1062814.17356466,231.50154851686)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 0.817004 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 919.96 | 926.04 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 18.5651 | 2 | yes | ((-642692.335749511,-1062842.94788942,229.52),(-642685.424686585,-1062836.68509014,230.990038580217)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 1.05745 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 919.96 | 926.04 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-sanace | 13081.3 | 2 | yes | ((-642812.618010181,-1062875.29536521,228.916144040819),(-642619.402130982,-1062739.25048518,232.979916541216)) | ByLayer | 40 | zemní práce-sanace | Barva_40 | úprava podloží hydraulickými pojivy | D1.1.4 | zemina | ČSN 73 6133 | P100 | 255;165;0 | 3270.25 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 756.04 | 989 | sanace | 215663 | I1+S1+E1+Z1+M3+F1
záchytné systémy-svodidlo | 387.792 | 1 | no | ((-642990.01208225,-1062874.98957603,232.901455957803),(-642618.675340607,-1062671.41853322,234.310970253811)) | ByLayer | 4 | záchytné systémy-svodidlo | Barva_4 |  |  |  |  | P2 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | záchytné systémy | 565 | 1000 | svodidlo | 9113A1 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: svodidlo; Stavební výrobek: ocelové svodidlo N2; Specifikace: TP 203; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 425
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642985.955625719,-1062673.90732405,232.549999999889),(-642985.877414309,-1062673.82911264,234.900526119937)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 569.66 | 569.66 | svislé dopravní značení | 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.791681 | 2 | yes | ((-642986.067443008,-1062674.09132404,234.363649290663),(-642985.767818298,-1062673.45031084,235.063649290663)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 569.66 | 569.66 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: B20a; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.791681 | 2 | yes | ((-642857.630540539,-1062731.96212349,234.553649290663),(-642857.356936048,-1062731.31017914,235.253649290663)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 710.23 | 710.23 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: B20a; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.791681 | 2 | yes | ((-642818.005469435,-1062741.77470519,235.025178122421),(-642817.829876764,-1062741.09227327,235.725178122421)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 749.67 | 749.67 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: C4b; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.791681 | 2 | yes | ((-642806.851053921,-1062736.96764232,234.625178122421),(-642806.698543569,-1062736.28030725,235.325178122421)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 759.45 | 759.45 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: C4a; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.791681 | 2 | yes | ((-642802.683891219,-1062745.10824007,235.125178122421),(-642802.429947752,-1062744.44886225,235.825178122421)) | Continuous | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 765 | 765 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: C1; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.791681 | 2 | yes | ((-642803.038372926,-1062718.19742477,234.825178122421),(-642802.844203388,-1062717.51954715,235.525178122421)) | Continuous | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 759.7 | 759.7 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: C1; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.791681 | 2 | yes | ((-642789.954677478,-1062716.91390643,235.225178122421),(-642789.501946745,-1062716.36721158,235.925178122421)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 778.21 | 778.21 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: C4a; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.500027 | 2 | yes | ((-642802.676179378,-1062745.08037517,235.801898976089),(-642802.439837007,-1062744.47920544,236.440335590625)) | Continuous | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 765 | 765 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: P4; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.500027 | 2 | yes | ((-642803.030709584,-1062718.16774214,235.50212192093),(-642802.854022089,-1062717.54941712,236.140084249899)) | Continuous | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 759.7 | 759.7 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: P4; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.332 | 2 | yes | ((-642842.241372144,-1062720.07611264,233.499999999767),(-642842.068961697,-1062719.59408248,233.800000000047)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 720.21 | 720.28 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IS16d; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.669241 | 2 | yes | ((-642788.961981411,-1062738.11018042,235.10000872612),(-642788.895133059,-1062737.41562474,235.548706769943)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 777.47 | 777.47 | svislé dopravní značení | 914131, 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z3; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.669241 | 2 | yes | ((-642781.019159089,-1062726.09845568,235.099479913712),(-642780.402124584,-1062725.66095336,235.548177957535)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 786.51 | 786.51 | svislé dopravní značení | 914131, 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z3; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.669241 | 2 | yes | ((-642771.706585079,-1062747.00127887,235.113518238068),(-642771.111169401,-1062746.53058784,235.562216281891)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 800.48 | 800.48 | svislé dopravní značení | 914131, 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z3; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.669241 | 2 | yes | ((-642765.882067651,-1062736.39590202,235.113518238068),(-642765.8152193,-1062735.70134634,235.562216281891)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 794.22 | 794.22 | svislé dopravní značení | 914131, 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z3; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.791681 | 2 | yes | ((-642755.087217083,-1062735.28573223,234.925178122421),(-642755.027009425,-1062734.58681937,235.625178122421)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 798.9 | 798.9 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: C4a; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.791681 | 2 | yes | ((-642755.222304469,-1062753.26916064,234.827012972583),(-642754.721470867,-1062752.76590571,235.527012972583)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 817.11 | 817.11 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: C1; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.791681 | 2 | yes | ((-642748.987926251,-1062772.76461824,235.425178122421),(-642748.519408051,-1062772.23126368,236.125178122421)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 834.88 | 834.88 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: C4a; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.791681 | 2 | yes | ((-642710.605501313,-1062794.69404785,235.025178122421),(-642710.076344676,-1062794.22075991,235.725178122421)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 878.52 | 878.52 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: B20a; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.791681 | 2 | yes | ((-642629.426426225,-1062853.57366776,234.733225724998),(-642629.009936426,-1062852.99929571,235.433225724998)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 979.5 | 979.5 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: B20a; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.500027 | 2 | yes | ((-642755.187784768,-1062753.24003481,235.527012972627),(-642754.730044333,-1062752.78141857,236.164975301595)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 817.11 | 817.11 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: P4; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.500027 | 2 | yes | ((-642751.634906173,-1062729.27866841,235.527012972627),(-642751.571363871,-1062728.64212003,236.164975301595)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 795.53 | 795.53 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: P4; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.791681 | 2 | yes | ((-642751.640518451,-1062729.31322963,234.825178122421),(-642751.571011006,-1062728.61491607,235.525178122421)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 795.53 | 795.53 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: C1; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642549.876369815,-1062899.42396019,232.331430297231),(-642549.798158405,-1062899.34574878,234.681956417279)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1072.05 | 1072.05 | svislé dopravní značení | 914981 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.587153 | 2 | yes | ((-642548.919911947,-1062897.60836273,232.331430297231),(-642548.841700537,-1062897.53015132,234.681956417279)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1072.05 | 1072.05 | svislé dopravní značení | 914981 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: sloupek; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 9.764 | 2 | yes | ((-642549.876945114,-1062899.71138332,234.231941566159),(-642548.68027683,-1062897.29523725,236.131941566159)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1072.01 | 1072.01 | svislé dopravní značení | 914521 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IS9b; Specifikace: velikost velkoplošná, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642958.197041556,-1062686.58003737,233.401419311802),(-642958.097041556,-1062686.48003737,233.701419311802)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 600.05 | 600.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642954.026709924,-1062676.46499762,233.437005536542),(-642953.926709924,-1062676.36499762,233.737005536542)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 600.05 | 600.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642912.760521344,-1062707.55157844,233.424369657565),(-642912.660521344,-1062707.45157844,233.724369657565)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 650.05 | 650.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642907.803091397,-1062695.52745052,233.512030244197),(-642907.703091397,-1062695.42745052,233.812030244197)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 650.05 | 650.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642861.576013401,-1062714.58151257,233.63315317055),(-642861.476013401,-1062714.48151257,233.93315317055)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 700.05 | 700.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642866.827587463,-1062727.31908001,233.526686770478),(-642866.727587463,-1062727.21908001,233.826686770478)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 700.05 | 700.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642848.393139518,-1062735.07608517,233.61),(-642848.293139518,-1062734.97608517,233.91)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 719.63 | 719.63 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642843.10730794,-1062721.64212628,233.718020617959),(-642843.00730794,-1062721.54212628,234.018020617959)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 720.05 | 720.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642829.952681045,-1062742.81858025,233.653212247244),(-642829.852681045,-1062742.71858025,233.953212247244)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 738.78 | 738.78 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642811.724564006,-1062751.04544696,233.724026328809),(-642811.624564006,-1062750.94544696,234.024026328809)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 757.46 | 757.46 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642793.843631744,-1062760.00188868,233.825043736114),(-642793.743631744,-1062759.90188868,234.125043736114)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 771.01 | 771.01 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642776.339070668,-1062769.67328611,233.9260297571),(-642776.239070668,-1062769.57328611,234.2260297571)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 812.89 | 812.89 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642759.23945285,-1062780.04385298,234.042373378814),(-642759.13945285,-1062779.94385298,234.342373378814)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 832.19 | 832.19 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642745.577098397,-1062764.78997401,234.24),(-642745.477098397,-1062764.68997401,234.54)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 832.2 | 832.2 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642742.572689387,-1062791.09666178,234.199639496375),(-642742.472689387,-1062790.99666178,234.499639496375)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 851.74 | 851.74 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642731.275394069,-1062777.91183704,234.33),(-642731.175394069,-1062777.81183704,234.63)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 851.74 | 851.74 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642717.800307297,-1062790.14074231,234.388706171783),(-642717.700307297,-1062790.04074231,234.688706171783)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 870.04 | 870.04 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642726.365984845,-1062802.81367141,234.279494803459),(-642726.265984845,-1062802.71367141,234.579494803459)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 871.47 | 871.47 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642678.999462661,-1062821.23328028,234.345574711255),(-642678.899462661,-1062821.13328028,234.645574711255)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 920.04 | 920.04 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642686.678983525,-1062831.66754337,234.261622649276),(-642686.578983525,-1062831.56754337,234.561622649276)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 920.04 | 920.04 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642638.156916391,-1062849.61512105,234.1032585066),(-642638.056916391,-1062849.51512105,234.4032585066)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 970.04 | 970.04 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642645.037624498,-1062860.11441142,234.026895457411),(-642644.937624498,-1062860.01441142,234.326895457411)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 970.04 | 970.04 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-642595.832941189,-1062875.73644557,233.852477860327),(-642595.732941189,-1062875.63644557,234.152477860327)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1020.04 | 1020.04 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: naástavec na svodidlo; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
vozovka_chodník-obrusná vrstva | 1905.96 | 1 | no | ((-643498.710568951,-1062520.34216985,230.38375),(-643296.182674124,-1062421.6059984,231.650477489754)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 37.7449 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0 | 222 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 1905.46 | 1 | no | ((-643500.481214377,-1062524.18115294,230.38375),(-643298.006052532,-1062425.46958673,231.650477489754)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 37.735 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0 | 222 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 1919.54 | 1 | no | ((-643498.710568951,-1062520.34216985,230.31375),(-643296.182674124,-1062421.6059984,231.610477489754)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 66.0536 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0 | 222 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 1919.04 | 1 | no | ((-643500.481214377,-1062524.18115294,230.31375),(-643298.006052532,-1062425.46958673,231.610477489754)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 66.0363 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0 | 222 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
zemní práce-rozprostření ornice (ohumusovani) | 324.239 | 1 | no | ((-643369.326947013,-1062526.13938959,230.030385821649),(-643303.962155933,-1062493.67148588,231.319313410436)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 21.719 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 146.96 | 218.31 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 23.4262 | 1 | no | ((-643500.4896523,-1062524.19944743,230.383243670886),(-643299.82943094,-1062429.33317506,231.544227489754)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0898983 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0 | 222 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 72.2009 | 1 | no | ((-643500.525249789,-1062524.27662728,230.311107594937),(-643299.82943094,-1062429.33317506,231.504227489754)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.36677 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0 | 222 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-zpevnění krajnic | 318.327 | 1 | no | ((-643368.5410254,-1062524.55909111,230.891500187872),(-643303.162571554,-1062491.98802243,231.525603336883)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 14.5096 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 146.96 | 218.31 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 633.538 | 1 | no | ((-643496.694300393,-1062471.50210084,229.382678571429),(-643385.722073295,-1062418.48778328,230.851834980593)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 42.2948 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 0 | 121.03 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 23.4385 | 1 | no | ((-643496.939923525,-1062516.50318676,230.383243670886),(-643296.173984904,-1062421.58758666,231.544227489754)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0899498 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0 | 222 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 72.2391 | 1 | no | ((-643496.939923525,-1062516.50318676,230.311107594937),(-643296.137327259,-1062421.50991214,231.504227489754)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.36748 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0 | 222 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-zpevnění krajnic | 721.668 | 1 | no | ((-643496.939923525,-1062516.50318676,230.244322036225),(-643295.251241565,-1062420.70704965,231.544227489754)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 31.3873 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0 | 222 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 2546.8 | 1 | no | ((-643298.006052532,-1062647.28571027,231.504227489754),(-643028.016620314,-1062516.50318676,232.662218708766)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 50.4384 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 222 | 518.7 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 2546.86 | 1 | no | ((-643299.82943094,-1062651.12749353,231.504227489754),(-643029.834091464,-1062520.34216985,232.662218708766)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 50.4396 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 222 | 518.7 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 2564.86 | 1 | no | ((-643298.006052532,-1062647.28571027,231.434227489754),(-643028.016620314,-1062516.50318676,232.622218708766)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 88.2673 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 222 | 518.7 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 2564.92 | 1 | no | ((-643299.82943094,-1062651.12749353,231.434227489754),(-643029.834091464,-1062520.34216985,232.622218708766)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 88.2692 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 222 | 518.7 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
zemní práce-rozprostření ornice (ohumusovani) | 1095.97 | 1 | no | ((-643295.383089745,-1062641.75923563,230.509112147101),(-643026.171838611,-1062513.26524125,232.715313116294)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 41.3384 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 222 | 518.7 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 31.316 | 1 | no | ((-643296.182674124,-1062643.44392701,231.50372116064),(-643028.007959246,-1062516.48489227,232.555968708766)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.12018 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 222 | 518.7 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 96.5144 | 1 | no | ((-643296.182674124,-1062643.44392701,231.43158508469),(-643027.971420362,-1062516.40771242,232.515968708766)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.82711 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 222 | 518.7 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-zpevnění krajnic | 1322.45 | 1 | no | ((-643296.182674124,-1062643.44392701,231.270226514997),(-643027.088205349,-1062514.5421271,232.555968708766)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 60.337 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 222 | 518.7 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 299.057 | 1 | no | ((-643029.834091464,-1062662.20596715,232.515968708766),(-642996.568960659,-1062643.44392701,232.714183228436)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 5.91679 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 518.7 | 553.5 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 298.977 | 1 | no | ((-643031.651562613,-1062666.04374593,232.515968708766),(-642998.394872494,-1062647.28571027,232.714183228436)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 5.91521 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 518.7 | 553.5 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 301.4 | 1 | no | ((-643029.834091464,-1062662.20596715,232.445968708766),(-642996.568960659,-1062643.44392701,232.674183228436)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 10.3544 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 518.7 | 553.5 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 301.319 | 1 | no | ((-643031.651562613,-1062666.04374593,232.445968708766),(-642998.394872494,-1062647.28571027,232.674183228436)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 10.3516 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 518.7 | 553.5 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-obrusná vrstva | 98.7925 | 1 | no | ((-642998.394872494,-1062667.10409504,232.567933228436),(-642986.216601556,-1062658.36818837,232.73135541166)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.95008 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 553.5 | 565 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 99.2874 | 1 | no | ((-643000.22078433,-1062670.96629452,232.567933228436),(-642987.990274347,-1062662.20596715,232.73135541166)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.95989 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 553.5 | 565 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 99.7357 | 1 | no | ((-642998.394872494,-1062667.10409504,232.497933228436),(-642986.216601556,-1062658.36818837,232.69135541166)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 3.41265 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 553.5 | 565 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
