Properties of the parts of a building model (IFC4X3_ADD2), part 2 of 21

# IfcBuiltElement (2093)
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | Linetype | ColorIndex | Layer | PlotStyleName | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | Skupina elementů | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Tloušťka
zemní práce-zemní krajnice a dosypávky | 16.9663 | 1 | no | ((-640088.031325503,-1063689.61934961,229.86),(-640083.334309042,-1063678.6149415,232.465544659269)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.447792 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.75906 | 3.75972 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 13.8292 | 1 | no | ((-640087.932223319,-1063689.52260803,230.059680510368),(-640083.239138993,-1063678.57755607,232.574044127635)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.526374 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.75933 | 3.75983 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 1.95925 | 1 | no | ((-640083.523001826,-1063700.38872017,232.511544127635),(-640081.206387382,-1063689.33979375,234.099999999999)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0113462 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.75553 | 3.75983 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 3.61775 | 1 | no | ((-640083.56986387,-1063700.38872017,232.455460794302),(-640081.206387382,-1063689.33979375,234.039999999999)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | TP 210 | P2 | 128;128;128 | 0.0568227 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.75551 | 3.75983 | ložní vrstva | 53630 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-horní podkladní vrstva | 3.82872 | 1 | no | ((-640083.600677269,-1063700.38872017,232.451460794302),(-640081.206387382,-1063689.33979375,233.989999999999)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 2.1388e-13 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.7555 | 3.75983 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
zemní práce-rozprostření ornice (ohumusovani) | 67.744 | 1 | no | ((-640088.305635051,-1063699.36492268,229.894643098622),(-640081.705967709,-1063689.52260803,234.004624711461)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 4.66964 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.75438 | 3.75933 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 18.5583 | 1 | no | ((-640083.950789251,-1063700.38872017,232.234044127635),(-640081.206387382,-1063689.33979375,233.989999999999)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 0.96962 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.75539 | 3.75983 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
zemní práce-zemní krajnice a dosypávky | 16.9471 | 1 | no | ((-640083.950789251,-1063700.30819477,232.234044127635),(-640081.308551293,-1063689.37717918,233.991500531633)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.459775 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.75534 | 3.75972 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 15.4181 | 1 | no | ((-640084.304891822,-1063700.38872017,232.433724638003),(-640081.206387382,-1063689.33979375,234.099999999999)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.603679 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.75517 | 3.75983 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 1.91006 | 1 | no | ((-640081.882277767,-1063687.33751123,230.137499999994),(-640077.550265531,-1063676.37235892,232.579507877575)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.011033 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.76583 | 3.76586 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 3.55666 | 1 | no | ((-640081.882277767,-1063687.33751123,230.08141666666),(-640077.479488924,-1063676.34455591,232.519507877575)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | TP 210 | P2 | 128;128;128 | 0.0554717 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.76583 | 3.76593 | ložní vrstva | 53630 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
zemní práce-rozprostření ornice (ohumusovani) | 74.3044 | 1 | no | ((-640081.41689734,-1063687.15469695,229.856360119766),(-640072.552546804,-1063676.10156727,232.539507877575)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 5.11767 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.76633 | 3.77123 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 18.9156 | 1 | no | ((-640081.882277767,-1063687.33751123,229.859999999994),(-640076.867701549,-1063676.10422895,232.469507877575)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 0.969286 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.76583 | 3.76659 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
zemní práce-zemní krajnice a dosypávky | 17.9904 | 1 | no | ((-640081.787107717,-1063687.30012581,229.859999999994),(-640076.867701549,-1063676.10422895,232.471008409209)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.543822 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.76593 | 3.76659 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 14.0665 | 1 | no | ((-640081.882277767,-1063687.33751123,230.059680510362),(-640077.113971381,-1063676.20097054,232.579507877575)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.53574 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.76583 | 3.76633 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 1.96451 | 1 | no | ((-640080.214969347,-1063716.71632564,232.353526927251),(-640072.489370327,-1063708.7459953,234.100000000005)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0113678 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.75553 | 3.75983 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 3.63138 | 1 | no | ((-640080.214969347,-1063716.74412865,232.297443593917),(-640072.489370327,-1063708.7459953,234.040000000005)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | TP 210 | P2 | 128;128;128 | 0.0569318 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.75551 | 3.75983 | ložní vrstva | 53630 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
zemní práce-rozprostření ornice (ohumusovani) | 68.1774 | 1 | no | ((-640080.108286266,-1063718.59914539,229.867925549864),(-640072.954750755,-1063709.4060957,234.003985636355)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 4.68923 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.75465 | 3.75933 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 18.5298 | 1 | no | ((-640080.214969347,-1063716.98445561,232.076026927251),(-640072.489370327,-1063708.7459953,233.990000000005)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 0.969569 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.75539 | 3.75983 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
zemní práce-zemní krajnice a dosypávky | 17.1646 | 1 | no | ((-640080.206578334,-1063716.98445561,232.076026927251),(-640072.584540377,-1063708.848245,233.991500531638)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.454391 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.75533 | 3.75972 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 15.4874 | 1 | no | ((-640080.214969347,-1063716.88771402,232.275707437619),(-640072.489370327,-1063708.7459953,234.100000000005)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.605212 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.75516 | 3.75983 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 1.12291 | 1 | no | ((-640072.518456604,-1063722.92344583,230.797500000114),(-640069.513847343,-1063716.70489975,232.416026927251)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00646805 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.7598 | 3.76033 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 2.096 | 1 | no | ((-640072.589233211,-1063722.95124883,230.741416666781),(-640069.513847343,-1063716.70489975,232.356026927251)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | TP 210 | P2 | 128;128;128 | 0.0325199 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.75972 | 3.76033 | ložní vrstva | 53630 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
zemní práce-rozprostření ornice (ohumusovani) | 51.5224 | 1 | no | ((-640077.301263509,-1063723.55158254,229.806913036374),(-640069.97922777,-1063716.88771402,232.376026927251)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 3.51215 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.75466 | 3.75984 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 10.6618 | 1 | no | ((-640072.980269115,-1063723.16049512,230.520000000114),(-640069.513847343,-1063716.70489975,232.306026927251)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 0.561519 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.7593 | 3.76033 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
zemní práce-zemní krajnice a dosypávky | 10.0372 | 1 | no | ((-640073.201020586,-1063723.16049512,230.520000000114),(-640069.609017393,-1063716.74228517,232.307527458884)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.293967 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.75906 | 3.76023 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 8.31643 | 1 | no | ((-640072.954750755,-1063723.09483421,230.719680510482),(-640069.513847343,-1063716.70489975,232.416026927251)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.314074 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.75933 | 3.76033 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 1.07219 | 1 | no | ((-640066.788831438,-1063721.08387721,230.797499999861),(-640064.830956794,-1063714.79493075,232.323657246089)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00616453 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.76533 | 3.76586 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 1.99949 | 1 | no | ((-640066.788831438,-1063721.08387721,230.741416666528),(-640064.760180188,-1063714.76712774,232.263657246089)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | TP 210 | P2 | 128;128;128 | 0.0309939 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.76533 | 3.76593 | ložní vrstva | 53630 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
zemní práce-rozprostření ornice (ohumusovani) | 54.0291 | 1 | no | ((-640066.323451011,-1063720.90106294,229.581477727217),(-640061.627988906,-1063712.7790353,232.283657246089)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 3.67926 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.76583 | 3.77137 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 10.9465 | 1 | no | ((-640066.788831438,-1063721.08387721,230.519999999861),(-640064.369144284,-1063714.52680078,232.213657246089)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 0.537017 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.76533 | 3.76659 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
zemní práce-zemní krajnice a dosypávky | 9.57816 | 1 | no | ((-640066.693661388,-1063721.04649179,230.519999999861),(-640064.227513208,-1063714.52680078,232.215157777723)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.280068 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.76543 | 3.76659 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 7.93231 | 1 | no | ((-640066.788831438,-1063721.08387721,230.71968051023),(-640064.394662644,-1063714.62354237,232.323657246089)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.299336 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.76533 | 3.76633 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 2.01554 | 1 | no | ((-640068.946437073,-1063714.80635664,232.261157246089),(-640066.628678304,-1063703.43682595,234.03)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0116655 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.76583 | 3.77012 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 3.72515 | 1 | no | ((-640068.946437073,-1063714.80635664,232.205073912756),(-640066.581672263,-1063703.43682595,233.97)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | TP 210 | P2 | 128;128;128 | 0.0584287 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.76583 | 3.77015 | ložní vrstva | 53630 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-horní podkladní vrstva | 3.94583 | 1 | no | ((-640068.946437073,-1063714.80635664,232.201073912756),(-640066.550764181,-1063703.43682595,233.92)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.5 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.77 | 3.7658 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
zemní práce-rozprostření ornice (ohumusovani) | 75.2114 | 1 | no | ((-640068.446528866,-1063714.62354237,229.58159653306),(-640061.605693018,-1063704.45869227,233.935937650413)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 5.19723 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.76633 | 3.7714 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 20.2366 | 1 | no | ((-640068.946437073,-1063714.80635664,231.983657246089),(-640066.07718118,-1063703.43682595,233.92)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 0.992635 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.76583 | 3.77027 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
zemní práce-zemní krajnice a dosypávky | 17.5852 | 1 | no | ((-640068.84420611,-1063714.76897122,231.983657246089),(-640066.07718118,-1063703.51719946,233.921500531633)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.473355 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.76593 | 3.77032 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 15.7077 | 1 | no | ((-640068.946437073,-1063714.80635664,232.183337756458),(-640065.844385732,-1063703.43682595,234.03)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.612156 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.76583 | 3.77049 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 1.92575 | 1 | no | ((-640077.579351808,-1063695.08218224,232.517007877575),(-640069.940535543,-1063687.32608533,234.05)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0111531 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.76583 | 3.77012 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 3.55513 | 1 | no | ((-640077.579351808,-1063695.08218224,232.460924544242),(-640069.940535543,-1063687.29828233,233.99)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | TP 210 | P2 | 128;128;128 | 0.0558519 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.76583 | 3.77014 | ložní vrstva | 53630 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
zemní práce-rozprostření ornice (ohumusovani) | 65.7386 | 1 | no | ((-640077.113971381,-1063694.42683003,229.926810128196),(-640070.046185625,-1063685.36677875,233.95)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 4.53028 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.76633 | 3.77122 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 18.7374 | 1 | no | ((-640077.579351808,-1063695.08218224,232.239507877575),(-640069.940535543,-1063687.14467264,233.94)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 0.954423 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.76583 | 3.77026 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
zemní práce-zemní krajnice a dosypávky | 16.7467 | 1 | no | ((-640077.484181758,-1063694.97993259,232.239507877575),(-640069.949177697,-1063687.05795537,233.941500531633)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.444673 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.76593 | 3.77032 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 15.0833 | 1 | no | ((-640077.579351808,-1063695.08218224,232.439188387944),(-640069.940535543,-1063687.15469695,234.05)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.590264 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3.76583 | 3.77047 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 1106.93 | 1 | no | ((-640571.392228135,-1063819.77992335,228.916938609306),(-640061.611051304,-1063684.37093522,236.672858497254)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 532.109 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.25165 | 3.77138 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 395.781 | 2 | yes | ((-640571.403643886,-1063833.55678971,230.746164757694),(-640554.110125468,-1063817.44443305,234.335083651707)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 242.741 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.25164 | 3.26868 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 168.289 | 2 | yes | ((-640076.750300762,-1063723.55158254,229.349879491472),(-640061.731882649,-1063715.08705771,231.818693548423)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 82.0176 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.75502 | 3.77043 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 303.299 | 2 | yes | ((-640088.300599903,-1063691.06146245,229.624065218083),(-640073.471477776,-1063676.10156727,232.136529204747)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 151.043 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.75449 | 3.77074 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-ložní vrstva | 825.806 | 1 | no | ((-639437.066774314,-1063501.08149918,230.07),(-639392.807042058,-1063463.86403841,230.586310574297)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 24.4297 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.43679 | 4.477 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 827.665 | 1 | no | ((-639437.066774314,-1063501.08149918,230),(-639392.807042058,-1063463.86403841,230.526310574297)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 28.5013 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.43679 | 4.477 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 851.828 | 1 | no | ((-639437.066774314,-1063501.08149918,229.8),(-639392.807042058,-1063463.86403841,230.456310574297)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 81.4324 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.43679 | 4.477 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 1059.5 | 1 | no | ((-639437.066774314,-1063501.08149918,229.453231075539),(-639392.807042058,-1063463.86403841,230.256310574297)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 136.628 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.43679 | 4.477 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 330.822 | 1 | no | ((-639432.849471144,-1063493.10673068,229.15),(-639393.175145051,-1063462.86939422,230.142289339701)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 21.8527 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.441 | 4.477 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 5.90066 | 1 | no | ((-639433.534087907,-1063493.82210969,230.129493670886),(-639393.113782672,-1063463.85816228,230.349999646709)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0226408 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.44032 | 4.477 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 16.701 | 1 | no | ((-639433.534087907,-1063493.82210969,230.067484177215),(-639393.113782672,-1063463.83484141,230.309999646709)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.286299 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.44032 | 4.477 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 27.1409 | 1 | no | ((-639433.534087907,-1063493.82210969,229.995348101266),(-639393.113782672,-1063463.8100515,230.249999646709)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.657471 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.44032 | 4.477 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 81.2053 | 1 | no | ((-639433.534087907,-1063493.82210969,229.785055893474),(-639393.113782672,-1063463.69060682,230.179999646709)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 4.91339 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.44032 | 4.477 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 240.913 | 1 | no | ((-639433.534087907,-1063493.82210969,229.406882833314),(-639393.113782672,-1063463.3006731,229.979999646709)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 21.4326 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.44032 | 4.477 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 142.648 | 1 | no | ((-639433.534087907,-1063493.82210969,229.921900956954),(-639393.113782672,-1063463.51000338,230.349999646709)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 7.36788 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.44032 | 4.477 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 166.18 | 1 | no | ((-639433.360644526,-1063493.64087289,229.569117952037),(-639393.129328447,-1063463.41834781,230.185021277488)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 10.0157 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.44049 | 4.477 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 512.665 | 1 | no | ((-639455.744181002,-1063503.68681181,230.260003274528),(-639432.590401169,-1063464.93490683,230.738601673716)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 10.1583 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.41413 | 4.4372 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 514.874 | 1 | no | ((-639455.744181002,-1063503.68681181,230.200003274528),(-639432.590401169,-1063464.93490683,230.698601673716)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 15.2374 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.41413 | 4.4372 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 515.979 | 1 | no | ((-639455.744181002,-1063503.68681181,230.130003274528),(-639432.590401169,-1063464.93490683,230.638601673716)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 17.777 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.41413 | 4.4372 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 530.342 | 1 | no | ((-639455.744181002,-1063503.68681181,229.930003274528),(-639432.590401169,-1063464.93490683,230.568601673716)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 50.7915 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.41413 | 4.4372 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 590.935 | 1 | no | ((-639455.744181002,-1063503.68681181,229.614705710686),(-639432.590401169,-1063464.93490683,230.368601673716)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 72.7655 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.41413 | 4.4372 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 290.365 | 1 | no | ((-639457.644713568,-1063502.07463638,228.963092266462),(-639440.689232835,-1063465.33488129,230.502230926526)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 9.79116 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.41285 | 4.43302 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 4.70502 | 1 | no | ((-639455.751730835,-1063502.73846142,230.259496945414),(-639439.973895112,-1063465.26085903,230.709941233536)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0180514 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.41412 | 4.43372 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 13.3163 | 1 | no | ((-639455.781694236,-1063502.73846142,230.197487451743),(-639439.973895112,-1063465.26085903,230.669941233536)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.228223 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.4141 | 4.43372 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 21.6376 | 1 | no | ((-639455.813545096,-1063502.73846142,230.125351375794),(-639439.973895112,-1063465.26085903,230.609941233536)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.524001 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.41408 | 4.43372 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 64.7075 | 1 | no | ((-639455.967011391,-1063502.73846142,229.915059168001),(-639439.973895112,-1063465.26085903,230.539941233536)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 3.91328 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.41398 | 4.43372 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 187.778 | 1 | no | ((-639456.447860658,-1063502.73846142,229.547697523135),(-639439.973895112,-1063465.26085903,230.339941233536)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 16.3206 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.41365 | 4.43372 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 113.454 | 1 | no | ((-639456.199056388,-1063502.73846142,230.051904231473),(-639439.973895112,-1063465.26085903,230.709941233536)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 5.85932 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.41382 | 4.43372 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 128.865 | 1 | no | ((-639456.29666847,-1063502.57028549,229.709932641858),(-639440.155121456,-1063465.2796121,230.544962864317)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 7.59837 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.41376 | 4.43354 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 76.807 | 1 | no | ((-639464.44145013,-1063503.91828058,229.035295601485),(-639455.990787589,-1063497.9367028,230.572289692983)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 1.95 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.406 | 4.414 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 0.869778 | 1 | no | ((-639463.73959234,-1063504.62696788,230.669434904422),(-639455.744181002,-1063502.71966805,230.78)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00333424 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.41413 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 2.46799 | 1 | no | ((-639463.750568355,-1063504.62696788,230.607425410751),(-639455.744181002,-1063502.64464866,230.74)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0421525 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.41413 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 4.01671 | 1 | no | ((-639463.762235772,-1063504.62696788,230.535289334802),(-639455.744181002,-1063502.56435158,230.68)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0967812 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.41413 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 12.1134 | 1 | no | ((-639463.818452634,-1063504.62696788,230.324997127009),(-639455.744181002,-1063502.17745792,230.61)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.722689 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.41413 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 34.7875 | 1 | no | ((-639464.001975671,-1063504.62696788,230.011747698178),(-639455.744181002,-1063500.9144223,230.41)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 2.88097 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.40599 | 4.41413 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 21.2479 | 1 | no | ((-639463.90345398,-1063504.62696788,230.461842190473),(-639455.744181002,-1063501.59246473,230.78)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.9 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.406 | 4.414 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 23.6081 | 1 | no | ((-639463.946591847,-1063504.44742638,230.173982816902),(-639455.808216151,-1063501.29558286,230.615021630775)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.8 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.406 | 4.414 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 0.309201 | 1 | no | ((-639393.115358144,-1063493.64350681,230.284310385476),(-639390.202496505,-1063493.37350166,230.339385871621)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00118353 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.4799 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 0.883528 | 1 | no | ((-639393.122303511,-1063493.64350681,230.222300891805),(-639390.202496505,-1063493.29341007,230.299385871621)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0149793 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.4799 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 1.44386 | 1 | no | ((-639393.129686382,-1063493.64350681,230.150164815856),(-639390.202496505,-1063493.20827334,230.239385871621)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0344347 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.4799 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 4.43961 | 1 | no | ((-639393.165259107,-1063493.64350681,229.939872608064),(-639390.202496505,-1063492.79806093,230.169385871621)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.258278 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.4799 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 13.8213 | 1 | no | ((-639393.289269937,-1063493.64350681,229.590077926283),(-639390.202496505,-1063491.36801072,229.969385871621)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 1.17658 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.4799 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 20.5702 | 1 | no | ((-639393.448058909,-1063492.930794,229.226978876752),(-639390.263018101,-1063489.78170964,230.131675564615)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 1.32672 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.477 | 4.4799 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 7.81674 | 1 | no | ((-639393.219045984,-1063493.64350681,230.07671767153),(-639390.202496505,-1063492.17780917,230.339385871621)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.390435 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 4.477 | 4.4799 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 9.39232 | 1 | no | ((-639393.254224339,-1063493.46294547,229.752313045006),(-639390.217829273,-1063491.77214449,230.174407502404)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.553016 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.477 | 4.4799 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 3409.86 | 1 | no | ((-639393.791476804,-1063544.02855646,228.655),(-638910.17266082,-1063486.03999012,230.173508598059)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 364.731 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.476 | 4.96 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-výkop_odkop | 16478.4 | 1 | no | ((-639393.417353338,-1063543.55590004,228.075846937911),(-638910.276375449,-1063486.3560144,230.14)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 4737.31 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.476 | 4.96 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-násyp | 1784.82 | 1 | no | ((-639464.44145013,-1063504.62696788,228.982436841052),(-639392.830531535,-1063459.54218485,229.672100945821)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 132.797 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.40597 | 4.477 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-výkop_odkop | 758.843 | 1 | no | ((-639464.380293516,-1063502.1678931,228.895258855162),(-639392.807042058,-1063460.52316522,229.87)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 47.2262 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.40597 | 4.477 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-aktivní zóna | 2203.11 | 1 | no | ((-639464.001975672,-1063504.62696788,228.90688283331),(-639392.807042058,-1063459.64799244,230.14)) | ByLayer | 16 | zemní práce-aktivní zóna | Barva_16 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 128;0;0 | 526.466 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 4.40599 | 4.477 | aktivní zóna | 17180 | I1+S1+E1+Z1+M3+F1
zemní práce-aktivní zóna | 34839.8 | 1 | no | ((-640606.541041139,-1063813.41306157,229.273023121658),(-639391.683279864,-1063497.20889489,236.486259737664)) | ByLayer | 16 | zemní práce-aktivní zóna | Barva_16 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 128;0;0 | 8386.91 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3.215 | 4.477 | aktivní zóna | 17180 | I1+S1+E1+Z1+M3+F1
dopravní značení-svislé dopravní značení | 0.332 | 2 | yes | ((-639475.87138704,-1063505.0103949,231.359999999953),(-639475.806715055,-1063504.5106116,231.66)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 4.394 | 4.39407 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IS16d; Specifikace: velikost základní, RA2; Podrobná specifikace: TP65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.332 | 2 | yes | ((-639364.612464803,-1063508.33088708,230.849999999953),(-639364.547792818,-1063507.83110378,231.15)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 4.50427 | 4.50433 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IS16d; Specifikace: velikost základní, RA2; Podrobná specifikace: TP65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 1.268 | 2 | yes | ((-639224.96357901,-1063493.14136684,230.470526120048),(-639224.938712536,-1063492.64119584,231.670526120048)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 4.64425 | 4.64432 | svislé dopravní značení | 914131, 914924 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IP19; Specifikace: velikost základní, RA2; Podrobná specifikace: TP65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 1.268 | 2 | yes | ((-639629.236514894,-1063550.13897285,232.030526120048),(-639629.107439894,-1063549.64674168,233.230526120048)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 4.23502 | 4.23508 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IP19; Specifikace: velikost základní, RA2; Podrobná specifikace: TP65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.469995 | 2 | yes | ((-639285.032686985,-1063491.10972781,231.71052612015),(-639284.950834981,-1063490.01034476,231.920526120113)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 4.58447 | 4.58457 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IS3c; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.469995 | 2 | yes | ((-639571.826731269,-1063537.56778612,231.474385598932),(-639571.559014235,-1063536.49164767,231.684385598895)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 4.29416 | 4.29423 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: IS3b; Specifikace: velikost základní, RA2; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.588 | 2 | yes | ((-639435.796270436,-1063476.15507033,231.449999999953),(-639435.49572195,-1063476.10684606,232.34999999986)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 4.4368 | 4.43709 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z4b; Specifikace: velikost základní, RA2; Podrobná specifikace: TP65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.588 | 2 | yes | ((-639412.872371827,-1063498.30953648,231.449999999953),(-639412.824147557,-1063498.00898799,232.34999999986)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 4.45704 | 4.45706 | svislé dopravní značení | 914131 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z4b; Specifikace: velikost základní, RA2; Podrobná specifikace: TP65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-640589.9201172,-1063793.34126655,237.521632574306),(-640589.8201172,-1063793.24126655,237.821632574306)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3.23005 | 3.23005 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z11 a,b; Specifikace: nerelevantni; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-640585.016643737,-1063794.12939244,237.496537917298),(-640584.916643737,-1063794.02939244,237.796537917298)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3.23505 | 3.23505 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z11 e,f; Specifikace: nerelevantni; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-640560.423713199,-1063797.54286422,237.371037224054),(-640560.323713198,-1063797.44286422,237.671037224054)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3.26005 | 3.26005 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z11 a,b; Specifikace: nerelevantni; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-640555.490981035,-1063798.12019612,237.345943766587),(-640555.390981034,-1063798.02019612,237.645943766587)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3.26505 | 3.26505 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z11 e,f; Specifikace: nerelevantni; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-640530.774380232,-1063800.47685922,237.220441873899),(-640530.674380231,-1063800.37685922,237.520441873899)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3.29005 | 3.29005 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z11 a,b; Specifikace: nerelevantni; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-640525.821447496,-1063800.84233712,237.195349597752),(-640525.721447496,-1063800.74233712,237.495349597752)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3.29505 | 3.29505 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z11 e,f; Specifikace: nerelevantni; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-640501.026567923,-1063802.13786339,237.069846522523),(-640500.926567923,-1063802.03786339,237.369846522523)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3.32005 | 3.32005 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z11 a,b; Specifikace: nerelevantni; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-640496.062529842,-1063802.29081635,237.044755423593),(-640495.962529842,-1063802.19081635,237.344755423593)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3.32505 | 3.32505 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z11 e,f; Specifikace: nerelevantni; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
dopravní značení-svislé dopravní značení | 0.109956 | 2 | yes | ((-640471.234906749,-1063802.52282638,236.919251173432),(-640471.134906749,-1063802.42282638,237.219251173432)) | ByLayer | 7 | dopravní značení-svislé dopravní značení | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3.35005 | 3.35005 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: Z11 a,b; Specifikace: nerelevantni; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: výpočet z délky
