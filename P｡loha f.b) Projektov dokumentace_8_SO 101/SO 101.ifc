Properties of the parts of a building model (IFC4X3_ADD2), part 20 of 21

# IfcGeographicElement (125)
Miscellaneous - IsHighlighting: no; NeedsPromoting: no; SupportsBaseCurveCommands: no; SupportsProfileCommands: no; SwappingReferences: no; TypeIcon: (Ikona)
General - LayerKey: AeccSurfaceTin; ColorIndex: 256; Linetype: ByLayer; LinetypeScale: 1; PlotStyleName: ByLayer; Visible: yes
Geometry - Closed: no; IsPeriodic: no; IsPlanar: yes
Misc - BlockName: *Model_Space; HasFields: no; IsAProxy: no
3D Visualization - CastShadows: yes; Material: ByLayer; ReceiveShadows: yes
CZ_I1 - Označení stavebního objektu: SO 101; Označení podobjektu: nerelevantni; Označení části objektu: nerelevantni; Fáze projektu: PDPS; Název stavebního objektu: Přeložka silnice II/322; Klasifikační systém: OTSKP
CZ_E1 - Datum zahájení prací: 01.05.2025; Datum dokončení: 30.06.2027; Doba trvání: 790; Datum uvedení do provozu: 01.07.2027; Stavební postup / etapa výstavby: nerelevantni
CZ_F1 - Fáze: trvalý stav
Name | FingerPrint | IsReferenceObject = IsReferenceValid | Name | StyleName | Bounds | Layer | Staničení od | Staničení do | Označení elementu | Skupina elementů | Označení položky | Označení šablony vlastností | Textura / barva | Skupina přesnosti | Description = Properties, Description | Typ stavebního výrobku | Stavební výrobek | Specifikace | Podrobná specifikace | CZ_S2, Reference | Výrobce = Kategorie stavebního výrobku | Délka | Způsob stanovení délky
zemní práce-pláň-4 | 1715869527 | yes | zemní práce-pláň-4 | plan | ((-639564.001975671,-1063604.62696788,229.406882833314),(-639292.807042058,-1063359.64799244,230.14)) | zemní práce-pláň | 4.406 | 4.47585 | pláň | zemní práce | 18110 | I1+S1+E1+Z1+M2+F1 | 0;128;0 | P10 | CZ_S1 - Materiál: nerelevantni; specifikace: ČSN 73 6133; podrobná specifikace: nerelevantni; Reference: D.1.1.4; CZ_M2 - Plocha: 1052.14; Způsob stanovení plochy: 3D plocha TIN povrchu
zemní práce-pláň-3 | -464438698 | yes | zemní práce-pláň-3 | plan | ((-640711.496119549,-1063913.41306157,228.423110066092),(-638810.690860222,-1063389.41105986,236.511358962699)) | zemní práce-pláň | 3.225 | 4.96 | pláň | zemní práce | 18110 | I1+S1+E1+Z1+M2+F1 | 0;128;0 | P10 | CZ_S1 - Materiál: nerelevantni; specifikace: ČSN 73 6133; podrobná specifikace: nerelevantni; Reference: D.1.1.4; CZ_M2 - Plocha: 23433.2; Způsob stanovení plochy: 3D plocha TIN povrchu
zemní práce-pláň-2 | 1582774481 | yes | zemní práce-pláň-2 | plan | ((-642630.029414403,-1063894.09023845,230.574866992318),(-640538.163269391,-1062811.35639191,238.933558245177)) | zemní práce-pláň | 1135 | 3180 | pláň | zemní práce | 915621 | I1+S1+E1+Z1+M2+F1 | 0;128;0 | P10 | CZ_S1 - Materiál: nerelevantni; specifikace: ČSN 73 6133; podrobná specifikace: nerelevantni; Reference: D.1.1.4; CZ_M2 - Plocha: 25005.4; Způsob stanovení plochy: 3D plocha TIN povrchu
zemní práce-pláň-1 | 1217749184 | yes | zemní práce-pláň-1 | plan | ((-643090.235495677,-1063022.51579097,231.913416375383),(-642424.645554484,-1062561.10817313,233.140653447312)) | zemní práce-pláň | 565 | 1100 | pláň | zemní práce | 18110 | I1+S1+E1+Z1+M2+F1 | 0;128;0 | P10 | Popis | CZ_S1 - Materiál: nerelevantni; specifikace: ČSN 73 6133; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 10170.3; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-2.1 | -2132994351 | yes | vozovka_chodník-spojovací postřik-2.1 | postřiky | ((-643600.546080911,-1062771.06234624,230.309857594937),(-642886.151624116,-1062321.50991214,232.62135541166)) | vozovka_chodník-spojovací postřik | 11.57 | 560 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em. 0,50 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D.1.1.4; CZ_M2 - Plocha: 4950.39; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-1.1 | 1440565726 | yes | vozovka_chodník-spojovací postřik-1.1 | postřiky | ((-643600.510483423,-1062771.03013728,230.381993670886),(-642886.187282467,-1062321.54213268,232.69135541166)) | vozovka_chodník-spojovací postřik | 11.57 | 558.07 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em. 0,25 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D.1.1.4; CZ_M2 - Plocha: 4883.45; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-2.7 | 2029732017 | yes | vozovka_chodník-spojovací postřik-2.7 | postřiky | ((-642897.34993639,-1062856.9318311,233.219999999833),(-642657.351387637,-1062616.93299452,233.570000000018)) | vozovka_chodník-spojovací postřik | 769.04 | 808.66 | spojovací postřik | vozovka/chodník | 572214 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em 0,25 kg/m2 modifikovaný; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 654.118; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-1.5 | -1370720621 | yes | vozovka_chodník-spojovací postřik-1.5 | postřiky | ((-642919.10988094,-1062873.90992006,232.578188948017),(-642635.187261964,-1062608.1749905,233.630000000018)) | vozovka_chodník-spojovací postřik | 753.5 | 815.79 | spojovací postřik | vozovka/chodník | 572214 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | Popis | CZ_S1 - Materiál: kat. em 0,25 kg/m2 modifikovaný; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 305.225; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-infiltrační postřik-8 | 1187931987 | yes | vozovka_chodník-infiltrační postřik-8 | postřiky | ((-642919.10988094,-1062873.90992006,232.578188948017),(-642635.187261964,-1062608.1749905,233.630000000018)) | vozovka_chodník-infiltrační postřik | 793.86 | 804.94 | infiltrační postřik | vozovka/chodník | 572123 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | Popis | CZ_S1 - Materiál: kat. em 1,0 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 135.572; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-2.2 | 2122573459 | yes | vozovka_chodník-spojovací postřik-2.2 | postřiky | ((-643089.827065543,-1062841.08899148,232.521324370083),(-642711.1284161,-1062563.10500747,233.138188948216)) | vozovka_chodník-spojovací postřik | 575 | 749.33 | spojovací postřik | vozovka/chodník | 572214 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em 0,25 kg/m2 modifikovaný; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 2113.98; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-1.4 | 309654136 | yes | vozovka_chodník-spojovací postřik-1.4 | postřiky | ((-642867.029850715,-1063020.82717146,232.649472497217),(-642425.460230153,-1062653.68025469,233.720653447312)) | vozovka_chodník-spojovací postřik | 816.7 | 1100 | spojovací postřik | vozovka/chodník | 572214 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em 0,25 kg/m2 modifikovaný; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 2917.76; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-2.4 | 2021406585 | yes | vozovka_chodník-spojovací postřik-2.4 | postřiky | ((-642867.029850715,-1063020.8995663,232.587463003547),(-642425.425303213,-1062653.62126451,233.660653447312)) | vozovka_chodník-spojovací postřik | 816.7 | 1100 | spojovací postřik | vozovka/chodník | 572214 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em 0,25 kg/m2 modifikovaný; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 2956.6; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-2.5 | -354019204 | yes | vozovka_chodník-spojovací postřik-2.5 | postřiky | ((-642919.10988094,-1062873.90992006,232.518188948017),(-642635.187261964,-1062608.1749905,233.570000000018)) | vozovka_chodník-spojovací postřik | 753.5 | 815.79 | spojovací postřik | vozovka/chodník | 572214 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | Popis | CZ_S1 - Materiál: kat. em 0,25 kg/m2 modifikovaný; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 305.225; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-infiltrační postřik-5 | -230248775 | yes | vozovka_chodník-infiltrační postřik-5 | postřiky | ((-642937.062635644,-1062883.84787747,232.819635189398),(-642644.187119077,-1062634.37277555,233.350014897541)) | vozovka_chodník-infiltrační postřik | 745 | 845.8 | infiltrační postřik | vozovka/chodník | 572123 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | Popis | CZ_S1 - Materiál: kat. em 1,0 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 37.17; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-1.3 | -787487261 | yes | vozovka_chodník-spojovací postřik-1.3 | postřiky | ((-642959.245926528,-1062919.17631103,232.765231612716),(-642600.342090731,-1062625.96171213,233.609878665549)) | vozovka_chodník-spojovací postřik | 716.34 | 900 | spojovací postřik | vozovka/chodník | 572214 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em 0,25 kg/m2 modifikovaný; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 814.705; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-1.7 | 753093471 | yes | vozovka_chodník-spojovací postřik-1.7 | postřiky | ((-642897.34993639,-1062856.9318311,233.279999999833),(-642657.351387637,-1062616.93299452,233.630000000018)) | vozovka_chodník-spojovací postřik | 769.04 | 808.66 | spojovací postřik | vozovka/chodník | 572214 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em 0,25 kg/m2 modifikovaný; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 654.118; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-infiltrační postřik-6 | 128899294 | yes | vozovka_chodník-infiltrační postřik-6 | postřiky | ((-642897.34993639,-1062856.9318311,233.149999999833),(-642657.351387637,-1062616.93299452,233.500000000018)) | vozovka_chodník-infiltrační postřik | 769.04 | 808.66 | infiltrační postřik | vozovka/chodník | 572123 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em 1,0 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 654.118; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-1.8 | 998703218 | yes | vozovka_chodník-spojovací postřik-1.8 | postřiky | ((-642919.10988094,-1062873.90992006,232.578188948017),(-642635.187261964,-1062608.1749905,233.630000000018)) | vozovka_chodník-spojovací postřik | 760.07 | 782.89 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | Popis | CZ_S1 - Materiál: kat. em 0,25 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 176.209; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-infiltrační postřik-1 | -1996007947 | yes | vozovka_chodník-infiltrační postřik-1 | postřiky | ((-643089.841857155,-1062841.08899148,232.450438294134),(-642711.160233609,-1062563.24189556,233.068188948216)) | vozovka_chodník-infiltrační postřik | 575 | 749.2 | infiltrační postřik | vozovka/chodník | 572123 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em 1,0 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 2090.82; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-infiltrační postřik-2 | -269972053 | yes | vozovka_chodník-infiltrační postřik-2 | postřiky | ((-642959.289815987,-1062919.12057768,232.632336043096),(-642600.342090731,-1062625.96171213,233.479878665549)) | vozovka_chodník-infiltrační postřik | 716.34 | 890.05 | infiltrační postřik | vozovka/chodník | 572123 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em 1,0 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 807.193; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-2.8 | 601852646 | yes | vozovka_chodník-spojovací postřik-2.8 | postřiky | ((-642919.10988094,-1062873.90992006,232.528188948017),(-642635.187261964,-1062608.1749905,233.580000000018)) | vozovka_chodník-spojovací postřik | 760.07 | 782.89 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | Popis | CZ_S1 - Materiál: kat. em 0,25 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 176.209; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-2.3 | -362770178 | yes | vozovka_chodník-spojovací postřik-2.3 | postřiky | ((-642959.276385333,-1062919.24006357,232.703222119045),(-642600.342090731,-1062625.96171213,233.549878665549)) | vozovka_chodník-spojovací postřik | 725.85 | 893.81 | spojovací postřik | vozovka/chodník | 572214 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em 0,25 kg/m2 modifikovaný; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 829.251; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-infiltrační postřik-7 | -816958053 | yes | vozovka_chodník-infiltrační postřik-7 | postřiky | ((-642919.10988094,-1062873.90992006,232.468188948017),(-642635.187261964,-1062608.1749905,233.520000000018)) | vozovka_chodník-infiltrační postřik | 760.07 | 782.89 | infiltrační postřik | vozovka/chodník | 572123 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | Popis | CZ_S1 - Materiál: kat. em 1,0 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 176.209; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-2.6 | -502386567 | yes | vozovka_chodník-spojovací postřik-2.6 | postřiky | ((-642937.062635644,-1062883.84787747,232.889635189398),(-642644.187119077,-1062634.37277555,233.420014897541)) | vozovka_chodník-spojovací postřik | 745 | 845.8 | spojovací postřik | vozovka/chodník | 572214 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | Popis | CZ_S1 - Materiál: kat. em 0,25 kg/m2 modifikovaný; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 37.1658; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-1.9 | -1187933261 | yes | vozovka_chodník-spojovací postřik-1.9 | postřiky | ((-642919.10988094,-1062873.90992006,232.578188948017),(-642635.187261964,-1062608.1749905,233.630000000018)) | vozovka_chodník-spojovací postřik | 793.86 | 804.94 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | Popis | CZ_S1 - Materiál: kat. em 0,25 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 135.572; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-1.2 | 78044816 | yes | vozovka_chodník-spojovací postřik-1.2 | postřiky | ((-643089.79352028,-1062841.08899148,232.583333863754),(-642711.145394351,-1062563.1780528,233.198188948216)) | vozovka_chodník-spojovací postřik | 575 | 749.33 | spojovací postřik | vozovka/chodník | 572214 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em 0,25 kg/m2 modifikovaný; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 2087.4; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-infiltrační postřik-4 | 289023136 | yes | vozovka_chodník-infiltrační postřik-4 | postřiky | ((-642919.10988094,-1062873.90992006,232.448188948017),(-642635.187261964,-1062608.1749905,233.500000000018)) | vozovka_chodník-infiltrační postřik | 753.5 | 815.79 | infiltrační postřik | vozovka/chodník | 572123 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | Popis | CZ_S1 - Materiál: kat. em 1,0 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 305.225; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-1.6 | 732536201 | yes | vozovka_chodník-spojovací postřik-1.6 | postřiky | ((-642937.062635644,-1062883.84787747,232.949635189398),(-642644.187119077,-1062634.37277555,233.480014897541)) | vozovka_chodník-spojovací postřik | 745 | 845.8 | spojovací postřik | vozovka/chodník | 572214 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | Popis | CZ_S1 - Materiál: kat. em 0,25 kg/m2 modifikovaný; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 37.1658; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-infiltrační postřik-3 | -230922856 | yes | vozovka_chodník-infiltrační postřik-3 | postřiky | ((-642867.029850715,-1063021.02155445,232.514076927597),(-642425.366449943,-1062653.52186372,233.590653447312)) | vozovka_chodník-infiltrační postřik | 816.73 | 1100 | infiltrační postřik | vozovka/chodník | 572123 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em 1,0 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D1.1.4; CZ_M2 - Plocha: 3022.06; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-infiltrační postřik-9 | -33514682 | yes | vozovka_chodník-infiltrační postřik-9 | postřiky | ((-642629.308518944,-1063892.52389193,231.097318746756),(-640538.593672168,-1062812.85062843,239.379808245177)) | vozovka_chodník-infiltrační postřik | 1135 | 3177.76 | infiltrační postřik | vozovka/chodník | 572123 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em 1,0 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D.1.1.4; CZ_M2 - Plocha: 18828.1; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-1.10 | -1753608557 | yes | vozovka_chodník-spojovací postřik-1.10 | postřiky | ((-642629.249665674,-1063892.39300236,231.170704822705),(-640538.625123465,-1062812.97261658,239.449808245177)) | vozovka_chodník-spojovací postřik | 1135 | 3175 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em. 0,25 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D.1.1.4; CZ_M2 - Plocha: 18285.9; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-2.9 | 1005965641 | yes | vozovka_chodník-spojovací postřik-2.9 | postřiky | ((-642629.214738734,-1063892.31554937,231.232714316376),(-640538.643788486,-1062813.04501142,239.509808245177)) | vozovka_chodník-spojovací postřik | 1135 | 3180 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em. 0,25 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D.1.1.4; CZ_M2 - Plocha: 17965.3; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-infiltrační postřik-10 | 1143152172 | yes | vozovka_chodník-infiltrační postřik-10 | postřiky | ((-640711.189627841,-1063911.78128086,228.94556182053),(-638811.04539716,-1063391.12961777,236.911628260813)) | vozovka_chodník-infiltrační postřik | 3.235 | 4.94 | infiltrační postřik | vozovka/chodník | 572123 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em 1,0 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D.1.1.4; CZ_M2 - Plocha: 17275.1; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-infiltrační postřik-11 | -573849676 | yes | vozovka_chodník-infiltrační postřik-11 | postřiky | ((-639563.775890972,-1063604.34357163,229.992848101266),(-639292.807042058,-1063359.88536343,230.602848101266)) | vozovka_chodník-infiltrační postřik | 4.41439 | 4.47488 | infiltrační postřik | vozovka/chodník | 572123 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em 1,0 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D.1.1.4; CZ_M2 - Plocha: 721.2; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-1.1 | -86100601 | yes | vozovka_chodník-spojovací postřik-1.1 | postřiky | ((-639563.757395955,-1063604.47774596,230.066234177215),(-639292.807042058,-1063359.90494152,230.676234177215)) | vozovka_chodník-spojovací postřik | 4.41439 | 4.47502 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em. 0,25 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D.1.1.4; CZ_M2 - Plocha: 706.92; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-1.11 | -1355897283 | yes | vozovka_chodník-spojovací postřik-1.11 | postřiky | ((-640711.164016289,-1063911.64671309,229.018947896479),(-638811.074341242,-1063391.26490538,236.978264063283)) | vozovka_chodník-spojovací postřik | 3.235 | 4.955 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em. 0,25 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D.1.1.4; CZ_M2 - Plocha: 16809.2; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-2.1 | 90666667 | yes | vozovka_chodník-spojovací postřik-2.1 | postřiky | ((-639563.74641994,-1063604.55737278,230.128243670886),(-639292.807042058,-1063359.9165603,230.738243670886)) | vozovka_chodník-spojovací postřik | 4.41602 | 4.47415 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em. 0,25 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D.1.1.4; CZ_M2 - Plocha: 698.16; Způsob stanovení plochy: 3D plocha TIN povrchu
vozovka_chodník-spojovací postřik-2.10 | -1808685068 | yes | vozovka_chodník-spojovací postřik-2.10 | postřiky | ((-640711.14886083,-1063911.56708353,229.08095739015),(-638811.091518338,-1063391.34519289,237.036273322542)) | vozovka_chodník-spojovací postřik | 3.235 | 4.96 | spojovací postřik | vozovka/chodník | 572213 | I1+S1+E1+Z1+M2+F1 | 0;255;255 | P2 | CZ_S1 - Materiál: kat. em. 0,25 kg/m2; specifikace: ČSN 73 6129; podrobná specifikace: nerelevantni; Reference: D.1.1.4; CZ_M2 - Plocha: 16533.1; Způsob stanovení plochy: 3D plocha TIN povrchu
dopravní značení-vodorovné dopravní značení-knofliky | 1767659527 | no | dopravní značení-vodorovné dopravní značení-knofliky | vdz | ((-643602.061458149,-1063926.09311208,200.02),(-638810.17266082,-1062318.48778328,239.569808245177)) | dopravní značení-vodorovné dopravní značení | 12.1 | 4942.8 | vodorovné dopravní značení | dopravní značení | 915621 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | nerelevantni | 306 ks | R 114 | D.1.1.6 | nerelevantni | 545.8 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-odrazky ostruvek | -1240505580 | yes | dopravní značení-vodorovné dopravní značení-odrazky ostruvek | vdz | ((-639536.409523506,-1063600.22354104,230.477412744476),(-639310.061673501,-1063372.02975878,230.739115870028)) | dopravní značení-vodorovné dopravní značení | 4.43589 | 4.45977 | vodorovné dopravní značení | dopravní značení | 915641 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | odrazky obrubnikove | 108 ks | TP 217 | D.1.1.6 | nerelevantni | 23.88 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-obrubnikove odrazky | -846697693 | yes | dopravní značení-vodorovné dopravní značení-obrubnikove odrazky | vdz | ((-642918.952257299,-1062874.1115674,233.155000000003),(-642646.793443191,-1062615.29361659,234.491000000018)) | dopravní značení-vodorovné dopravní značení | 748.64 | 836.66 | vodorovné dopravní značení | dopravní značení | 915641 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | odrazky obrubnikove | 344 ks | TP 217 | D1.1.6 | nerelevantni | 88.02 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (1) 0.25 barva | 1316204316 | no | dopravni značení-vodorovné dopravní značení-V4 (1) 0.25 barva | vdz | ((-643602.061458149,-1063893.70670127,229.47814419436),(-640538.31178625,-1062318.48778328,239.569808245177)) | dopravní značení-vodorovné dopravní značení | 0 | 3180 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | barva | TP 133 | D.1.1.6 | nerelevantni | 3171.4 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (2) 0.25 barva | 2030305384 | no | dopravni značení-vodorovné dopravní značení-V4 (2) 0.25 barva | vdz | ((-643600.272903151,-1063891.75823695,230.456249999992),(-640538.776201709,-1062322.06053821,239.48230889306)) | dopravní značení-vodorovné dopravní značení | 0 | 770 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | barva | TP 133 | D.1.1.6 | nerelevantni | 785.4 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (3) 0.25 barva | -54990965 | no | dopravni značení-vodorovné dopravní značení-V4 (3) 0.25 barva | vdz | ((-643600.272903151,-1063891.75823695,230.456249999992),(-640538.776201709,-1062322.06053821,239.48230889306)) | dopravní značení-vodorovné dopravní značení | 800 | 3180 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | barva | TP 133 | D.1.1.6 | nerelevantni | 2370.4 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (4) 0.25 barva | 450474271 | no | dopravni značení-vodorovné dopravní značení-V4 (4) 0.25 barva | vdz | ((-643602.061458149,-1063893.70670127,229.47814419436),(-640538.31178625,-1062318.48778328,239.569808245177)) | dopravní značení-vodorovné dopravní značení | 760 | 800 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | barva | TP 133 | D.1.1.6 | nerelevantni | 40.9 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (5) 0.25 barva | -434880632 | no | dopravni značení-vodorovné dopravní značení-V4 (5) 0.25 barva | vdz | ((-643600.272903151,-1063891.75823695,230.486249999992),(-640538.776201709,-1062322.06053821,239.51230889306)) | dopravní značení-vodorovné dopravní značení | 880 | 710 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | barva | TP 133 | D.1.1.6 | nerelevantni | 496.5 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (6) 0.25 barva | 1215557678 | no | dopravni značení-vodorovné dopravní značení-V4 (6) 0.25 barva | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 3220 | 4960 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | barvou | TP 133 | D.1.1.6 | nerelevantni | 1750 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (7) 0.25 barva | 808415795 | no | dopravni značení-vodorovné dopravní značení-V4 (7) 0.25 barva | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 3220 | 4440 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | barvou | TP 133 | D.1.1.6 | nerelevantni | 1249 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (9) 0.25 barva | 1610216564 | no | dopravni značení-vodorovné dopravní značení-V4 (9) 0.25 barva | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4440 | 4500 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | barvou | TP 133 | D.1.1.6 | nerelevantni | 95 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (8) 0.25 barva | 979520198 | no | dopravni značení-vodorovné dopravní značení-V4 (8) 0.25 barva | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4440 | 4960 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | barvou | TP 133 | D.1.1.6 | nerelevantni | 540.7 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (1) 0.25 plast | -227825513 | no | dopravni značení-vodorovné dopravní značení-V4 (1) 0.25 plast | vdz | ((-643600.272903151,-1063891.75823695,230.456249999992),(-640538.776201709,-1062322.06053821,239.48230889306)) | dopravní značení-vodorovné dopravní značení | 0 | 3180 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | plast | TP 133 | D.1.1.6 | nerelevantni | 3171.4 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (2) 0.25 plast | -2031034331 | no | dopravni značení-vodorovné dopravní značení-V4 (2) 0.25 plast | vdz | ((-643600.272903151,-1063891.75823695,230.456249999992),(-640538.776201709,-1062322.06053821,239.48230889306)) | dopravní značení-vodorovné dopravní značení | 0 | 770 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | plast | TP 133 | D.1.1.6 | nerelevantni | 785.4 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (3) 0.25 plast | -1653139340 | no | dopravni značení-vodorovné dopravní značení-V4 (3) 0.25 plast | vdz | ((-643600.272903151,-1063891.75823695,230.456249999992),(-640538.776201709,-1062322.06053821,239.48230889306)) | dopravní značení-vodorovné dopravní značení | 800 | 3180 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | plast | TP 133 | D.1.1.6 | nerelevantni | 2370.4 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (4) 0.25 plast | 1288765989 | no | dopravni značení-vodorovné dopravní značení-V4 (4) 0.25 plast | vdz | ((-643600.272903151,-1063891.75823695,230.456249999992),(-640538.776201709,-1062322.06053821,239.48230889306)) | dopravní značení-vodorovné dopravní značení | 760 | 800 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | plast | TP 133 | D.1.1.6 | nerelevantni | 40.9 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (5) 0.25 plast | 476322431 | no | dopravni značení-vodorovné dopravní značení-V4 (5) 0.25 plast | vdz | ((-643600.272903151,-1063891.75823695,230.486249999992),(-640538.776201709,-1062322.06053821,239.51230889306)) | dopravní značení-vodorovné dopravní značení | 880 | 710 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | plast | TP 133 | D.1.1.6 | nerelevantni | 496.5 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (6) 0.25 plast | 96483281 | no | dopravni značení-vodorovné dopravní značení-V4 (6) 0.25 plast | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 3220 | 4960 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | plast | TP 133 | D.1.1.6 | nerelevantni | 1750 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (7) 0.25 plast | -808415799 | no | dopravni značení-vodorovné dopravní značení-V4 (7) 0.25 plast | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 3220 | 4440 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | plast | TP 133 | D.1.1.6 | nerelevantni | 1249 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (9) 0.25 plast | -1564350696 | no | dopravni značení-vodorovné dopravní značení-V4 (9) 0.25 plast | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4440 | 4500 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | plast | TP 133 | D.1.1.6 | nerelevantni | 95 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 (8) 0.25 plast | -978203664 | no | dopravni značení-vodorovné dopravní značení-V4 (8) 0.25 plast | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4440 | 4960 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,25 | plast | TP 133 | D.1.1.6 | nerelevantni | 540.7 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 0.125 (1) | -2029041095 | no | dopravni značení-vodorovné dopravní značení-V4 0.125 (1) | vdz | ((-643090.285869659,-1063021.43939238,232.52510541166),(-642425.164863744,-1062561.87876633,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 789.7 | 817.33 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 25.3 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 0.125 (2) | -1653524637 | no | dopravni značení-vodorovné dopravní značení-V4 0.125 (2) | vdz | ((-643090.285869659,-1063021.43939238,232.52510541166),(-642425.164863744,-1062561.87876633,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 789.7 | 817.33 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 23.7 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 0.125 (1) plast | -335628858 | no | dopravni značení-vodorovné dopravní značení-V4 0.125 (1) plast | vdz | ((-643090.285869659,-1063021.43939238,232.52510541166),(-642425.164863744,-1062561.87876633,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 789.7 | 817.33 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 25.3 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 0.125 (2) plast | -1047607140 | no | dopravni značení-vodorovné dopravní značení-V4 0.125 (2) plast | vdz | ((-643090.285869659,-1063021.43939238,232.52510541166),(-642425.164863744,-1062561.87876633,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 789.7 | 817.33 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 23.7 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 0.125 (3) | 1034040167 | no | dopravni značení-vodorovné dopravní značení-V4 0.125 (3) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4450 | 4440 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,125 | barvou | TP 133 | D.1.1.6 | nerelevantni | 66.1 | Délka 3D křivky
dopravni značení-vodorovné dopravní značení-V4 0.125 (3) plast | -203567976 | no | dopravni značení-vodorovné dopravní značení-V4 0.125 (3) plast | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4450 | 4440 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V4 0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 66.1 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V1a barva | -492458510 | no | dopravní značení-vodorovné dopravní značení-V1a barva | vdz | ((-643602.061458149,-1063926.09311208,227.267351217847),(-638810.17266082,-1062318.48778328,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 0 | 50 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V1a 0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 50 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V1a barva (1) | 1973569674 | no | dopravní značení-vodorovné dopravní značení-V1a barva (1) | vdz | ((-643602.061458149,-1063669.72091123,229.47814419436),(-639132.575301103,-1062318.48778328,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 545 | 760 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V1a 0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 470 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V1a barva (2) | -1835356338 | no | dopravní značení-vodorovné dopravní značení-V1a barva (2) | vdz | ((-643602.061458149,-1063669.72091123,229.47814419436),(-639132.575301103,-1062318.48778328,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 740 | 820 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V1a 0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 25.2 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V1a barva (3) | -1900563908 | no | dopravní značení-vodorovné dopravní značení-V1a barva (3) | vdz | ((-643602.061458149,-1063669.72091123,229.50814419436),(-639132.575301103,-1062318.48778328,233.810653447312)) | dopravní značení-vodorovné dopravní značení | 833 | 1030 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V1a 0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 257.8 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V1a barva (5) | -1853628960 | no | dopravní značení-vodorovné dopravní značení-V1a barva (5) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4440 | 4636 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V1a 0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 322.8 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V1a barva (4) | -1046900219 | no | dopravní značení-vodorovné dopravní značení-V1a barva (4) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4135 | 4425 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V1a 0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 430.5 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V1a plast | 1410633887 | no | dopravní značení-vodorovné dopravní značení-V1a plast | vdz | ((-643602.061458149,-1063669.72091123,229.47814419436),(-639132.575301103,-1062318.48778328,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 0 | 50 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V1a 0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 50 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V1a plast (1) | 14965448 | no | dopravní značení-vodorovné dopravní značení-V1a plast (1) | vdz | ((-643602.061458149,-1063669.72091123,229.47814419436),(-639132.575301103,-1062318.48778328,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 545 | 760 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V1a 0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 470 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V1a plast (2) | -671396041 | no | dopravní značení-vodorovné dopravní značení-V1a plast (2) | vdz | ((-643602.061458149,-1063669.72091123,229.47814419436),(-639132.575301103,-1062318.48778328,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 740 | 820 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V1a 0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 25.2 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V1a plast (3) | 167407307 | no | dopravní značení-vodorovné dopravní značení-V1a plast (3) | vdz | ((-643602.061458149,-1063669.72091123,229.50814419436),(-639132.575301103,-1062318.48778328,233.810653447312)) | dopravní značení-vodorovné dopravní značení | 833 | 1030 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V1a 0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 257.8 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V1a plast (5) | 664740383 | no | dopravní značení-vodorovné dopravní značení-V1a plast (5) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4440 | 4636 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V1a 0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 322.8 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V1a plast (4) | 897179570 | no | dopravní značení-vodorovné dopravní značení-V1a plast (4) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4135 | 4425 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V1a 0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 430.5 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (2) | -443251488 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (2) | vdz | ((-643602.061458149,-1062772.10223554,229.47814419436),(-642884.345490345,-1062318.48778328,232.824865718883)) | dopravní značení-vodorovné dopravní značení | 440 | 536.85 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 81 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (1) | 989626852 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (1) | vdz | ((-643602.061458149,-1062772.10223554,229.47814419436),(-642884.345490345,-1062318.48778328,232.824865718883)) | dopravní značení-vodorovné dopravní značení | 59.45 | 155 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 81 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (2) | 443160809 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (2) | vdz | ((-643602.061458149,-1062772.10223554,229.47814419436),(-642884.345490345,-1062318.48778328,232.824865718883)) | dopravní značení-vodorovné dopravní značení | 440 | 536.85 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 81 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (1) | -989400638 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (1) | vdz | ((-643602.061458149,-1062772.10223554,229.47814419436),(-642884.345490345,-1062318.48778328,232.824865718883)) | dopravní značení-vodorovné dopravní značení | 59.45 | 155 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 81 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (3) | 644012922 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (3) | vdz | ((-643090.285869659,-1063893.70670127,231.23447064549),(-640538.31178625,-1062561.87876633,239.569808245177)) | dopravní značení-vodorovné dopravní značení | 620 | 710 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 90 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (4) | -1669966076 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (4) | vdz | ((-643090.285869659,-1063518.3168077,231.761650011587),(-641365.461187643,-1062561.87876633,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 1030 | 1140 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 81 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (5) | -856806108 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (5) | vdz | ((-643090.285869659,-1063518.3168077,231.761650011587),(-641365.461187643,-1062561.87876633,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 2150 | 2280 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 81 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (6) | 498299884 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (6) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 3240 | 3370 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 81 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (7) | -499491590 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (7) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 620 | 710 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 90 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (8) | 278396362 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (8) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4230 | 4390 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 158 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (9) | 2025356546 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 barva (9) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4636 | 4750 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 81 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (3) | 1589702503 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (3) | vdz | ((-643090.285869659,-1063518.3168077,231.761650011587),(-641365.461187643,-1062561.87876633,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 620 | 710 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 90 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (4) | -41309957 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (4) | vdz | ((-643090.285869659,-1063518.3168077,231.761650011587),(-641365.461187643,-1062561.87876633,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 1030 | 1140 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 81 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (5) | -753806629 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (5) | vdz | ((-643090.285869659,-1063518.3168077,231.761650011587),(-641365.461187643,-1062561.87876633,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 2150 | 2280 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 81 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (6) | -498531382 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (6) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 3240 | 3370 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 81 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (7) | -343146491 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (7) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 620 | 710 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 90 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (8) | -278394950 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (8) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4230 | 4390 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 158 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (9) | 335643389 | no | dopravní značení-vodorovné dopravní značení-V2b 3.0 1.5 plast (9) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4636 | 4750 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 3,0/1,5/0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 81 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2a barva (2) | 2033492089 | yes | dopravní značení-vodorovné dopravní značení-V2a barva (2) | vdz | ((-642629.510105143,-1063893.70670127,231.23447064549),(-640538.31178625,-1062812.43279051,239.569808245177)) | dopravní značení-vodorovné dopravní značení | 1153.55 | 2144.3 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2a 3,0/6,0/0,125 | barvou | TP 133 | D.1.1.6 | nerelevantni | 990.75 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2a barva (1) | -1210675499 | yes | dopravní značení-vodorovné dopravní značení-V2a barva (1) | vdz | ((-643602.061458149,-1062772.10223554,229.47814419436),(-642884.345490345,-1062318.48778328,232.824865718883)) | dopravní značení-vodorovné dopravní značení | 160.15 | 435.1 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 |  | VDZ | V2a 3,0/6,0/0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 274.95 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2a barva (3) | -2076109957 | no | dopravní značení-vodorovné dopravní značení-V2a barva (3) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 3380 | 4030 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2a 6,0/3,0/0,125 | barvou | TP 133 | D.1.1.6 | nerelevantni | 647 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2a barva (4) | -2049568161 | no | dopravní značení-vodorovné dopravní značení-V2a barva (4) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4750 | 4960 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2a 6,0/3,0/0,125 | barvou | TP 133 | D.1.1.6 | nerelevantni | 211 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2a plast (2) | 2033492089 | yes | dopravní značení-vodorovné dopravní značení-V2a plast (2) | vdz | ((-642629.510105143,-1063893.70670127,231.23447064549),(-640538.31178625,-1062812.43279051,239.569808245177)) | dopravní značení-vodorovné dopravní značení | 1153.55 | 2144.3 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2a 3,0/6,0/0,125 | barvou | TP 133 | D.1.1.6 | nerelevantni | 990.75 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2a plast (1) | -1210675499 | yes | dopravní značení-vodorovné dopravní značení-V2a plast (1) | vdz | ((-643602.061458149,-1062772.10223554,229.47814419436),(-642884.345490345,-1062318.48778328,232.824865718883)) | dopravní značení-vodorovné dopravní značení | 160.15 | 435.1 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 |  | VDZ | V2a 3,0/6,0/0,125 | barva | TP 133 | D.1.1.6 | nerelevantni | 274.95 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2a plast (3) | 2074661856 | no | dopravní značení-vodorovné dopravní značení-V2a plast (3) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 3380 | 4030 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2a 6,0/3,0/0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 647 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2a plast (4) | 1313467808 | no | dopravní značení-vodorovné dopravní značení-V2a plast (4) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4750 | 4960 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2a 6,0/3,0/0,125 | plast | TP 133 | D.1.1.6 | nerelevantni | 211 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V9b barva | -1420093819 | no | dopravní značení-vodorovné dopravní značení-V9b barva | vdz | ((-643602.061458149,-1063926.09311208,227.267351217847),(-638810.17266082,-1062318.48778328,239.569808245177)) | dopravní značení-vodorovné dopravní značení | 52 | 4750 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V9b | barva | TP 133 | D.1.1.6 | nerelevantni | 4 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V9b plast | -1091252827 | no | dopravní značení-vodorovné dopravní značení-V9b plast | vdz | ((-643602.061458149,-1063907.09681774,229.309266767467),(-639021.375451497,-1062318.48778328,236.829183189785)) | dopravní značení-vodorovné dopravní značení | 52 | 4750 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V9b | plast | TP 133 | D.1.1.6 | nerelevantni | 4 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 1.5-1.5-0.25 | 427086969 | no | dopravní značení-vodorovné dopravní značení-V2b 1.5-1.5-0.25 | vdz | ((-643090.285869659,-1063021.43939238,232.52510541166),(-642425.164863744,-1062561.87876633,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 770 | 820 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 1,5/1,5/0,25 | barva | TP 133 | D1.1.6 | nerelevantni | 69.4 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 1.5-1.5-0.25 (1) | -1929326704 | no | dopravní značení-vodorovné dopravní značení-V2b 1.5-1.5-0.25 (1) | vdz | ((-643090.285869659,-1063021.43939238,232.52510541166),(-642425.164863744,-1062561.87876633,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 875 | 1027.5 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 1,5/1,5/0,25 | barva | TP 133 | D1.1.6 | nerelevantni | 156.5 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 1.5-1.5-0.25 (2) | 1523149490 | no | dopravní značení-vodorovné dopravní značení-V2b 1.5-1.5-0.25 (2) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4410 | 4440 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 1,5/1,5/0,25 | barva | TP 133 | D1.1.6 | nerelevantni | 58 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 1.5-1.5-0.25 (3) | 545937771 | no | dopravní značení-vodorovné dopravní značení-V2b 1.5-1.5-0.25 (3) | vdz | ((-640713.362836696,-1063926.09311208,227.267351217847),(-638810.17266082,-1063359.54218485,237.094529495381)) | dopravní značení-vodorovné dopravní značení | 4495 | 4630 | vodorovné dopravní značení | dopravní značení | 915111 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 1,5/1,5/0,25 | barva | TP 133 | D1.1.6 | nerelevantni | 133.5 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 1.5-1.5-0.25 plast | -91542650 | no | dopravní značení-vodorovné dopravní značení-V2b 1.5-1.5-0.25 plast | vdz | ((-643090.285869659,-1063021.43939238,232.52510541166),(-642425.164863744,-1062561.87876633,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 770 | 820 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 1,5/1,5/0,25 | plast | TP 133 | D1.1.6 | nerelevantni | 69.4 | Délka 3D křivky
dopravní značení-vodorovné dopravní značení-V2b 1.5-1.5-0.25 (1) plast | 1929321489 | no | dopravní značení-vodorovné dopravní značení-V2b 1.5-1.5-0.25 (1) plast | vdz | ((-643090.285869659,-1063021.43939238,232.52510541166),(-642425.164863744,-1062561.87876633,233.780653447312)) | dopravní značení-vodorovné dopravní značení | 875 | 1027.5 | vodorovné dopravní značení | dopravní značení | 915211 | I1+S2+E1+Z1+M1+F1 | 255;255;255 | P10 | Popis | VDZ | V2b 1,5/1,5/0,25 | plast | TP 133 | D1.1.6 | nerelevantni | 156.5 | Délka 3D křivky
