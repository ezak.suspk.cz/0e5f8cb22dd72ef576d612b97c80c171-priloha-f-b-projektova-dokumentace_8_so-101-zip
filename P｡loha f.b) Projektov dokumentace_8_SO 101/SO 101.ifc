Properties of the parts of a building model (IFC4X3_ADD2), part 10 of 21

# IfcBuiltElement (2093)
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | Linetype | ColorIndex | Layer | PlotStyleName | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | Skupina elementů | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Tloušťka
zemní práce-zemní krajnice a dosypávky | 22.2199 | 1 | no | ((-640737.07876615,-1063765.97312539,237.299656578408),(-640731.578937456,-1063762.24355763,237.765141579352)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 1.95914 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3080.23 | 3085.32 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 73.8567 | 1 | no | ((-640774.151901417,-1063757.41901048,237.421780059804),(-640751.518285471,-1063746.48513257,237.994669761776)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 4.41586 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3040.18 | 3063.93 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 21.4472 | 1 | no | ((-640737.000689377,-1063765.77527191,237.580743694947),(-640731.512523374,-1063762.07273626,237.928764095113)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 1.25894 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3080.23 | 3085.32 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 62.3896 | 1 | no | ((-640773.987165775,-1063757.00478546,237.774638142411),(-640751.447523756,-1063746.31926843,238.15967896426)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 3.18119 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3040.18 | 3063.93 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-spodní podkladní vrstva | 24.4367 | 1 | no | ((-640737.07876615,-1063765.97312539,237.268842738019),(-640731.512523374,-1063762.0727351,237.573902570825)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 1.07783 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3080.23 | 3085.32 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-horní podkladní vrstva | 7.36386 | 1 | no | ((-640736.487016922,-1063764.47248421,237.518842738285),(-640731.512523374,-1063762.07273797,237.765141579352)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.438722 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3080.23 | 3085.32 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 34.7092 | 1 | no | ((-640773.731881182,-1063756.41626338,237.65273704921),(-640751.447523756,-1063746.31929382,237.989678964271)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 2.08262 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3040.18 | 3063.93 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 2.48315 | 1 | no | ((-640736.343425567,-1063764.10960839,237.718842738153),(-640731.512523374,-1063762.07273851,237.832119343556)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0596942 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3080.23 | 3085.32 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 11.6511 | 1 | no | ((-640773.565558328,-1063756.04994951,237.852737049343),(-640751.447523756,-1063746.31930121,238.059678964286)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.279959 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3040.18 | 3063.93 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 1.52179 | 1 | no | ((-640736.312291133,-1063764.03075158,237.788842738284),(-640731.512523374,-1063762.07273865,237.89033069334)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0259611 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3080.23 | 3085.32 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 7.15832 | 1 | no | ((-640773.530786174,-1063755.97166972,237.922737049343),(-640751.447523756,-1063746.3193056,238.11967896426)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.121772 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3040.18 | 3063.93 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-obrusná vrstva | 0.532539 | 1 | no | ((-640736.282976122,-1063763.95649956,237.848842738285),(-640731.512523374,-1063762.07273878,237.928764062689)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00202127 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3080.23 | 3085.32 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 2.52152 | 1 | no | ((-640773.498073212,-1063755.8979863,237.982737049194),(-640751.447523756,-1063746.31930834,238.15967896426)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00956652 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3040.18 | 3063.93 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
zemní práce-rozprostření ornice (ohumusovani) | 279.808 | 1 | no | ((-640775.333081697,-1063762.88672221,235.844599187898),(-640751.724030223,-1063746.97358478,237.951968657395)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 19.5171 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3040.18 | 3063.93 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 48.279 | 1 | no | ((-640736.27569843,-1063763.93808045,237.141342738033),(-640729.977195374,-1063758.12082703,237.558764055367)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 5.67831 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3080.23 | 3085.32 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 2.66611 | 1 | no | ((-640809.904657647,-1063729.61320743,237.888905508867),(-640808.060606117,-1063725.74240903,238.266880125998)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 0.0553847 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 48.4351 | 1 | no | ((-640734.711790159,-1063759.97509444,237.013842738126),(-640728.441867374,-1063754.16911494,237.463342029721)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 6.13119 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3080.23 | 3085.32 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 2.66701 | 1 | no | ((-640808.105905139,-1063725.763575,237.888853235358),(-640806.261140276,-1063721.89121288,238.266880125998)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 0.0553809 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-horní podkladní vrstva | 47.1056 | 1 | no | ((-640736.27569843,-1063763.93808045,237.412592738032),(-640729.977195374,-1063758.12082703,237.758764055367)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 4.33509 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3080.23 | 3085.32 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 2.14483 | 1 | no | ((-640809.904657647,-1063729.61320743,238.160151151417),(-640808.060606117,-1063725.74240903,238.466880125998)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.0425017 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 46.8332 | 1 | no | ((-640734.711790159,-1063759.97509444,237.306342738125),(-640728.441867374,-1063754.16911494,237.663342029721)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 4.30899 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3080.23 | 3085.32 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 2.14548 | 1 | no | ((-640808.105905139,-1063725.763575,238.160107590157),(-640806.261140276,-1063721.89121288,238.466880125999)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.0424983 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 44.6746 | 1 | no | ((-640736.27569843,-1063763.93808045,237.612592738032),(-640729.977195374,-1063758.12082703,237.828764055367)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.51728 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3080.23 | 3085.32 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 1.02705 | 1 | no | ((-640809.904657647,-1063729.61320743,238.360151151417),(-640808.060606117,-1063725.74240903,238.536880125998)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0148756 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 44.4102 | 1 | no | ((-640734.711790159,-1063759.97509444,237.506342738125),(-640728.441867374,-1063754.16911494,237.733342029721)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.50814 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3080.23 | 3085.32 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 1.02726 | 1 | no | ((-640808.105905139,-1063725.763575,238.360107590157),(-640806.261140276,-1063721.89121288,238.536880125998)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0148744 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 44.4876 | 1 | no | ((-640736.27569843,-1063763.93808045,237.682592738032),(-640729.977195374,-1063758.12082703,237.888764055367)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.30053 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3080.23 | 3085.32 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 0.941068 | 1 | no | ((-640809.904657647,-1063729.61320743,238.430151151417),(-640808.060606117,-1063725.74240903,238.596880125998)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0127505 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 44.2238 | 1 | no | ((-640734.711790159,-1063759.97509444,237.576342738125),(-640728.441867374,-1063754.16911494,237.793342029721)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.2927 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3080.23 | 3085.32 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 0.94124 | 1 | no | ((-640808.105905139,-1063725.763575,238.430107590157),(-640806.261140276,-1063721.89121288,238.596880126)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0127495 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-obrusná vrstva | 44.1136 | 1 | no | ((-640736.27569843,-1063763.93808045,237.742592738032),(-640729.977195374,-1063758.12082703,237.928764055367)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.867019 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3080.23 | 3085.32 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 0.769102 | 1 | no | ((-640809.904657647,-1063729.61320743,238.490151151417),(-640808.060606117,-1063725.74240903,238.636880125998)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00850036 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 43.851 | 1 | no | ((-640734.711790159,-1063759.97509444,237.636342738125),(-640728.441867374,-1063754.16911494,237.833342029721)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.861797 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3080.23 | 3085.32 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 0.769206 | 1 | no | ((-640808.105905139,-1063725.763575,238.490107590157),(-640806.261140276,-1063721.89121288,238.636880125998)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00849963 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000.05 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 810.527 | 1 | no | ((-640729.977195374,-1063788.11387433,236.972624845591),(-640638.660102009,-1063756.01210842,237.782592738455)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 16.0473 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 37.7004 | 1 | no | ((-640738.765900396,-1063758.12084161,237.687094418253),(-640733.147958075,-1063752.55921306,237.877063748158)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.739974 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 815.461 | 1 | no | ((-640731.512523375,-1063792.24770294,237.07887484559),(-640639.64699666,-1063759.97509444,237.888842738417)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 16.145 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 37.9141 | 1 | no | ((-640740.353136878,-1063762.07274609,237.793342029414),(-640734.711790159,-1063756.50159453,237.953932061822)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.7443 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 814.473 | 1 | no | ((-640729.977195374,-1063788.11387433,236.912624845591),(-640638.660102009,-1063756.01210842,237.742592738455)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 24.0709 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 38.0445 | 1 | no | ((-640738.765900396,-1063758.12084161,237.627094418253),(-640733.147958075,-1063752.55921306,237.837063748158)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.10996 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 819.43 | 1 | no | ((-640731.512523375,-1063792.24770294,237.01887484559),(-640639.64699666,-1063759.97509444,237.848842738417)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 24.2175 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 38.2592 | 1 | no | ((-640740.353136878,-1063762.07274609,237.733342029414),(-640734.711790159,-1063756.50159453,237.913932061822)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.11645 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 816.446 | 1 | no | ((-640729.977195374,-1063788.11387433,236.842624845591),(-640638.660102009,-1063756.01210842,237.682592738455)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 28.0827 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 38.2165 | 1 | no | ((-640738.765900396,-1063758.12084161,237.557094418252),(-640733.147958075,-1063752.55921306,237.777063748158)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.29495 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 821.414 | 1 | no | ((-640731.512523375,-1063792.24770294,236.94887484559),(-640639.64699666,-1063759.97509444,237.788842738417)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 28.2538 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 38.4318 | 1 | no | ((-640740.353136878,-1063762.07274609,237.663342029414),(-640734.711790159,-1063756.50159453,237.853932061822)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.30252 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 842.094 | 1 | no | ((-640729.977195374,-1063788.11387433,236.642624845591),(-640638.660102009,-1063756.01210842,237.612592738455)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 80.2364 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 40.4533 | 1 | no | ((-640738.765900396,-1063758.12084161,237.357094418253),(-640733.147958075,-1063752.55921306,237.707063748158)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 3.69987 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 847.212 | 1 | no | ((-640731.512523375,-1063792.24770294,236.74887484559),(-640639.64699666,-1063759.97509444,237.718842738417)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 80.725 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 40.6751 | 1 | no | ((-640740.353136878,-1063762.07274609,237.463342029414),(-640734.711790159,-1063756.50159453,237.783932061822)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 3.7215 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 858.296 | 1 | no | ((-640729.977195374,-1063788.11387433,236.350124845591),(-640638.660102009,-1063756.01210842,237.412592738455)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 113.079 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 42.2096 | 1 | no | ((-640738.765900396,-1063758.12084161,237.053763829528),(-640733.147958075,-1063752.55921306,237.507063748158)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 5.58632 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 859.291 | 1 | no | ((-640731.512523375,-1063792.24770294,236.47762484559),(-640639.64699666,-1063759.97509444,237.518842738417)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 105.19 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 41.8985 | 1 | no | ((-640740.353136878,-1063762.07274609,237.18126083732),(-640734.711790158,-1063756.50159453,237.583932061822)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 5.0363 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 3114.01 | 1 | no | ((-640736.716424842,-1063808.9996191,232.303622464568),(-640640.970412066,-1063765.30449698,237.621132708582)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 228.96 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3085.32 | 3180 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 105.794 | 1 | no | ((-640744.372167966,-1063774.63087414,235.182272561016),(-640736.814916609,-1063761.10770564,237.746224064929)) | ByLayer | 256 | zemní práce-rozprostření ornice (ohumusovani) | ByLayer | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 7.3626 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3075.87 | 3080.23 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 9.901 | 1 | no | ((-640731.51965925,-1063792.26691609,237.185124845589),(-640640.633891311,-1063763.93808045,237.888842755762)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0376193 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 0.457757 | 1 | no | ((-640740.360539079,-1063762.09112914,237.888764055202),(-640736.27569843,-1063760.44422494,237.953932087137)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00173863 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 28.1557 | 1 | no | ((-640731.548425743,-1063792.34436909,237.125124845589),(-640640.633891311,-1063763.93808045,237.850586591712)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.483378 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 1.30874 | 1 | no | ((-640740.390315217,-1063762.16520659,237.828764055054),(-640736.27569843,-1063760.44422452,237.915194864273)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0223009 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 45.8235 | 1 | no | ((-640731.578976206,-1063792.42662537,237.055124845589),(-640640.633891311,-1063763.93808045,237.79257733681)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.11147 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 2.13636 | 1 | no | ((-640740.421941905,-1063762.24388162,237.758764055202),(-640736.27569843,-1063760.44422408,237.856636865306)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0512777 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 134.045 | 1 | no | ((-640731.719560457,-1063792.80514462,236.855124845589),(-640640.633891311,-1063763.93808045,237.725941503764)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 8.16674 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 6.36283 | 1 | no | ((-640740.568365865,-1063762.60672909,237.558764055202),(-640736.27569843,-1063760.44422234,237.789072751949)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.377463 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 17.4967 | 1 | no | ((-640740.95973925,-1063764.10204759,237.308764054936),(-640736.27569843,-1063760.44421623,237.596163112238)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 0.918758 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 414.544 | 1 | no | ((-640732.300934303,-1063794.09023845,236.605124845589),(-640640.633891311,-1063763.93808045,237.535670419532)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 20.0928 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 101.255 | 1 | no | ((-640774.3173307,-1063757.41901048,237.351851599634),(-640751.447522455,-1063746.31919856,237.78967896426)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 8.35863 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3040.18 | 3063.93 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 364.813 | 1 | no | ((-640732.224282509,-1063793.95617454,236.934126881368),(-640640.633891311,-1063763.93808045,237.888842755762)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 22.4339 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 13.6143 | 1 | no | ((-640740.808846583,-1063763.9047493,237.62066505113),(-640736.27569843,-1063760.44422097,237.953932124202)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.724315 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 367.976 | 1 | no | ((-640732.300934303,-1063794.09023845,236.635938685745),(-640640.676581669,-1063764.10950836,237.725941503855)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 33.5591 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3085.32 | 3180 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 15.5072 | 1 | no | ((-640740.95973925,-1063764.10204569,237.339538915672),(-640736.343298329,-1063760.61442967,237.789072751949)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 1.078 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3075.87 | 3080.23 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 1919.81 | 1 | no | ((-640727.95050855,-1063782.62390958,232.768969827646),(-640635.946770925,-1063748.90189672,237.458563088972)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 135.706 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3085.32 | 3180 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 65.3854 | 1 | no | ((-640736.970127295,-1063752.90442777,235.482452569478),(-640730.418632435,-1063745.73517399,237.625805469185)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 4.53487 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3075.87 | 3080.23 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 9.93367 | 1 | no | ((-640728.441867387,-1063783.98004573,236.972118516477),(-640638.655399012,-1063755.99322301,237.676342738291)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0381178 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 0.458929 | 1 | no | ((-640737.178754911,-1063754.16912227,237.686588088472),(-640733.140505529,-1063752.54044848,237.770816178062)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0017571 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 28.1352 | 1 | no | ((-640728.441867375,-1063783.98004573,236.910109022806),(-640638.63673399,-1063755.91827152,237.636342738291)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.482441 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 1.30743 | 1 | no | ((-640737.178754878,-1063754.16912242,237.624578590846),(-640733.110928238,-1063752.465884,237.730816178062)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0222513 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 45.7618 | 1 | no | ((-640728.441867374,-1063783.98004573,236.837972946857),(-640638.616893219,-1063755.83859868,237.576342738292)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.10892 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 2.13313 | 1 | no | ((-640737.178754876,-1063754.16912256,237.552442510814),(-640733.079487809,-1063752.38662265,237.670816178192)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.051145 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 137.405 | 1 | no | ((-640728.441867374,-1063783.98004573,236.627680739065),(-640638.521294868,-1063755.4547128,237.506342738429)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 8.31492 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 6.50617 | 1 | no | ((-640737.178754876,-1063754.16912327,237.342150283355),(-640732.927999084,-1063752.00471943,237.600816178062)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.383502 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 462.178 | 1 | no | ((-640728.441867374,-1063783.98004573,236.285937489096),(-640638.163269391,-1063753.78054574,237.306342738292)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 40.8383 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 21.3982 | 1 | no | ((-640737.178754876,-1063754.16912367,236.981277074769),(-640732.258861285,-1063750.62790075,237.4008161782)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 1.87568 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 347.558 | 1 | no | ((-640728.441867387,-1063783.98004573,236.725105352003),(-640638.264989867,-1063754.37148167,237.676342738301)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 19.999 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3085.32 | 3180 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 11.6295 | 1 | no | ((-640737.178754911,-1063754.16912484,237.477370856699),(-640732.500535331,-1063751.5726836,237.770816178363)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.469764 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3075.87 | 3080.23 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 360.898 | 1 | no | ((-640728.384204571,-1063783.82009537,236.443075846453),(-640638.218000421,-1063754.07827557,237.554605528399)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 33.5734 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3085.32 | 3180 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 15.8053 | 1 | no | ((-640737.120826387,-1063754.02070499,237.140923321377),(-640732.376347441,-1063751.00414481,237.658087519982)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 1.20842 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3075.87 | 3080.23 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 547.935 | 1 | no | ((-640808.060606117,-1063751.96073487,237.85034281961),(-640748.158290611,-1063721.91236395,238.636379364163)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 10.8459 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3063.93 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 0.34047 | 1 | no | ((-640808.105947389,-1063725.74240903,238.490608477925),(-640806.306419281,-1063721.89119315,238.636880593057)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00000792761 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 549.276 | 1 | no | ((-640809.859334349,-1063755.87965575,237.956593197686),(-640749.802890959,-1063725.763575,238.636379364177)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 10.8737 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3063.93 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 0.340331 | 1 | no | ((-640809.90469992,-1063729.59203568,238.490651787086),(-640808.105905139,-1063725.74238928,238.636880593057)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00000792822 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 550.657 | 1 | no | ((-640808.060606117,-1063751.96073487,237.79034281961),(-640748.158290611,-1063721.91236395,238.596379364163)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 16.2688 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3063.93 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 0.510506 | 1 | no | ((-640808.105947389,-1063725.74240903,238.430608477923),(-640806.306419281,-1063721.89119315,238.596880593057)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0000118914 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 552.004 | 1 | no | ((-640809.859334349,-1063755.87965575,237.896593197686),(-640749.802890959,-1063725.763575,238.596379364177)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 16.3106 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3063.93 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 0.510298 | 1 | no | ((-640809.90469992,-1063729.59203568,238.430651787084),(-640808.105905139,-1063725.74238928,238.596880593057)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0000118924 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 552.018 | 1 | no | ((-640808.060606117,-1063751.96073487,237.72034281961),(-640748.158290611,-1063721.91236395,238.536379364163)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 18.9803 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3063.93 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 0.595524 | 1 | no | ((-640808.105947389,-1063725.74240903,238.360608477925),(-640806.306419281,-1063721.89119315,238.536880593057)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0000138734 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 553.369 | 1 | no | ((-640809.859334349,-1063755.87965575,237.826593197686),(-640749.802890959,-1063725.763575,238.536379364177)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 19.029 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3063.93 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 0.595282 | 1 | no | ((-640809.90469992,-1063729.59203568,238.360651787086),(-640808.105905139,-1063725.74238928,238.536880593057)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0000138744 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 569.71 | 1 | no | ((-640808.060606117,-1063751.96073487,237.52034281961),(-640748.158290611,-1063721.91236395,238.466379364163)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 54.2294 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3063.93 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 1.70076 | 1 | no | ((-640808.105947389,-1063725.74240903,238.160608477922),(-640806.306419282,-1063721.89119315,238.466880593057)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.000039638 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 571.105 | 1 | no | ((-640809.859334349,-1063755.87965575,237.626593197686),(-640749.802890959,-1063725.763575,238.466379364177)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 54.3687 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3063.93 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 1.70007 | 1 | no | ((-640809.90469992,-1063729.59203568,238.160651787085),(-640808.105905139,-1063725.74238928,238.466880593057)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.0000396413 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 578.542 | 1 | no | ((-640808.060606117,-1063751.96073487,237.196805739568),(-640748.158290611,-1063721.91236395,238.266379364163)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 71.3485 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3063.93 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 2.2162 | 1 | no | ((-640808.105947389,-1063725.74240903,237.889354148311),(-640806.306419282,-1063721.89119315,238.266880593057)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 0.0000516536 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 580.209 | 1 | no | ((-640809.859334349,-1063755.87965575,237.32430711974),(-640749.802890959,-1063725.763575,238.266379364177)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 72.3791 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3063.93 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 2.21526 | 1 | no | ((-640809.90469992,-1063729.59203568,237.889406119304),(-640808.105905139,-1063725.74238928,238.266880593057)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 0.0000516572 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-zemní krajnice a dosypávky | 136.66 | 1 | no | ((-640806.184418652,-1063740.07293877,237.426712766855),(-640765.529903837,-1063720.5795629,238.365129220939)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 9.74921 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3000.05 | 3043.88 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 0.335342 | 1 | no | ((-640806.229738944,-1063721.72701395,237.993235730015),(-640805.654722483,-1063720.49639678,238.365630575886)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.00000781111 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3000 | 3000 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 113.93 | 1 | no | ((-640806.261140276,-1063740.23865892,237.843066547921),(-640765.748504621,-1063720.80684201,238.530107590209)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 5.84183 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3043.88 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 0.267284 | 1 | no | ((-640806.306461513,-1063721.89121288,238.282509434858),(-640805.789861396,-1063720.78567419,238.530608945102)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.00000622613 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 38.3397 | 1 | no | ((-640805.450488266,-1063737.25858379,237.177628264938),(-640765.155125523,-1063719.4909183,238.634163451348)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 1.75666 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3000.05 | 3043.88 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 91.3693 | 1 | no | ((-640805.958304218,-1063739.47419126,237.172520839958),(-640765.459994337,-1063720.71193827,238.322397283151)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 4.6765 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3000.05 | 3043.88 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 114.15 | 1 | no | ((-640806.261140276,-1063740.23866363,237.419916126683),(-640765.79179928,-1063720.90374902,238.160107590157)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 10.8945 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3043.88 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 0.719059 | 1 | no | ((-640806.306461513,-1063721.89121288,237.831000611292),(-640805.483043348,-1063720.12894267,238.160608945102)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 0.0000167475 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-horní podkladní vrstva | 64.3786 | 1 | no | ((-640806.261140276,-1063740.23867264,237.706221484424),(-640766.000476568,-1063721.3708005,238.360107590157)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 3.86582 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3043.88 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 0.176836 | 1 | no | ((-640806.306461513,-1063721.89121288,238.145664371398),(-640806.053372407,-1063721.34963116,238.360608945102)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.00000411965 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 21.4183 | 1 | no | ((-640806.261140276,-1063740.23871292,237.913810625608),(-640766.16705134,-1063721.74378255,238.430107590157)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.515499 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3043.88 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 0.0235923 | 1 | no | ((-640806.306461513,-1063721.89121288,238.35595657919),(-640806.227649204,-1063721.72261221,238.430608945102)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 5.4931e-07 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 13.1655 | 1 | no | ((-640806.261140276,-1063740.23872016,237.985979713407),(-640766.2016253,-1063721.82119238,238.490107590157)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.224265 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3043.88 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
