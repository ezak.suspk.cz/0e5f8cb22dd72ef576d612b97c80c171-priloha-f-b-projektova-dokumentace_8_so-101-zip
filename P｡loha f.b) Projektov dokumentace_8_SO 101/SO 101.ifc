Properties of the parts of a building model (IFC4X3_ADD2), part 12 of 21

# IfcBuiltElement (2093)
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | Linetype | ColorIndex | Layer | PlotStyleName | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | Skupina elementů | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Tloušťka
odvodnění-trativod | 136.077 | 1 | no | ((-640958.205271688,-1063741.98656237,236.96611400283),(-640760.569495642,-1063649.94259738,238.582746980379)) | ByLayer | 40 | odvodnění-trativod | Barva_40 |  |  |  |  | P100 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2832 | 3050 | trativod | 21264 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: trativod; Stavební výrobek: nerelevantni; Specifikace: plast DN200, částečná perforace; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 218
odvodnění-trativod | 176.116 | 1 | no | ((-641217.878951274,-1063659.1817975,235.752346193873),(-640962.357503354,-1063539.51805241,238.579746979436)) | ByLayer | 40 | odvodnění-trativod | Barva_40 |  |  |  |  | P100 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2550 | 2832 | trativod | 21264 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: trativod; Stavební výrobek: nerelevantni; Specifikace: plast DN200, částečná perforace; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 282
odvodnění-trativod | 136.307 | 1 | no | ((-640962.439658509,-1063751.60310386,236.992743117474),(-640764.651971379,-1063659.00180074,238.579809461312)) | ByLayer | 40 | odvodnění-trativod | Barva_40 |  |  |  |  | P100 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2832 | 3050.11 | trativod | 21264 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: trativod; Stavební výrobek: nerelevantni; Specifikace: plast DN200, částečná perforace; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 218.11
odvodnění-trativod | 6.30552 | 1 | no | ((-641053.070846545,-1063616.76387607,238.04626117332),(-641048.652714671,-1063607.62109731,238.396261173625)) | ByLayer | 40 | odvodnění-trativod | Barva_40 |  |  |  |  | P100 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2731.9 | 2732.1 | trativod | 21264 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: trativod; Stavební výrobek: nerelevantni; Specifikace: plast DN200, částečná perforace; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
odvodnění-trativod | 6.30552 | 1 | no | ((-640962.490453457,-1063659.13358682,238.379746979436),(-640958.072321584,-1063649.99080806,238.729746980044)) | ByLayer | 40 | odvodnění-trativod | Barva_40 |  |  |  |  | P100 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2831.9 | 2832.1 | trativod | 21264 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: trativod; Stavební výrobek: nerelevantni; Specifikace: plast DN200, částečná perforace; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
odvodnění-trativod | 6.30552 | 1 | no | ((-641143.651239629,-1063574.39416532,237.055361743025),(-641139.233107754,-1063565.25138657,237.405361743351)) | ByLayer | 40 | odvodnění-trativod | Barva_40 |  |  |  |  | P100 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2631.9 | 2632.1 | trativod | 21264 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: trativod; Stavební výrobek: nerelevantni; Specifikace: plast DN200, částečná perforace; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
odvodnění-trativod | 6.3055 | 1 | no | ((-640871.910043184,-1063701.50326081,238.055363894904),(-640867.491928499,-1063692.3605188,238.405363894582)) | ByLayer | 40 | odvodnění-trativod | Barva_40 |  |  |  |  | P100 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2931.9 | 2932.1 | trativod | 21264 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: trativod; Stavební výrobek: nerelevantni; Specifikace: plast DN200, částečná perforace; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10
odvodnění-trativod | 6.30574 | 1 | no | ((-640781.651737934,-1063743.55166993,237.150086086019),(-640777.233457171,-1063734.40857287,237.500612999898)) | ByLayer | 40 | odvodnění-trativod | Barva_40 |  |  |  |  | P100 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 3031.41 | 3031.73 | trativod | 21264 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: trativod; Stavební výrobek: nerelevantni; Specifikace: plast DN200, částečná perforace; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 0.32
odvodnění-trativod | 8.89576 | 1 | no | ((-641218.824576589,-1063541.65447444,235.852855768273),(-641212.620795551,-1063528.5311476,236.086506711143)) | ByLayer | 40 | odvodnění-trativod | Barva_40 |  |  |  |  | P100 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2549.9 | 2550.1 | trativod | 21264 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: trativod; Stavební výrobek: nerelevantni; Specifikace: plast DN200, částečná perforace; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 14.5
odvodnění-trativod | 11.04 | 1 | no | ((-640765.71205646,-1063753.50655715,236.9391586479),(-640755.195649704,-1063741.49156442,237.30548759634)) | ByLayer | 40 | odvodnění-trativod | Barva_40 |  |  |  |  | P100 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 3049.9 | 3054.87 | trativod | 21264 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: trativod; Stavební výrobek: nerelevantni; Specifikace: plast DN200, částečná perforace; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 18.54
odvodnění-drenážní šachta | 3.07248 | 2 | yes | ((-640760.907100762,-1063742.19595083,236.666087769966),(-640760.307100762,-1063741.59595083,237.996087769966)) | ByLayer | 5 | odvodnění-drenážní šachta | Barva_5 |  |  |  |  | P100 | 0;0;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 3050.28 | 3050.28 | drenážní šachta | 895811 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: drenážní šachta; Stavební výrobek: nerelevantni; Specifikace: plast DN600 s kalníkem; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
odvodnění-drenážní šachta | 3.07248 | 2 | yes | ((-640764.909433983,-1063751.36004636,236.699424580541),(-640764.309433982,-1063750.76004636,238.029424580541)) | ByLayer | 5 | odvodnění-drenážní šachta | Barva_5 |  |  |  |  | P100 | 0;0;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 3050.27 | 3050.27 | drenážní šachta | 895811 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: drenážní šachta; Stavební výrobek: nerelevantni; Specifikace: plast DN600 s kalníkem; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
odvodnění-drenážní šachta | 3.07248 | 2 | yes | ((-640777.624037564,-1063734.75094258,236.850086086019),(-640777.024037564,-1063734.15094258,238.180086086019)) | ByLayer | 5 | odvodnění-drenážní šachta | Barva_5 |  |  |  |  | P100 | 0;0;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 3031.91 | 3031.91 | drenážní šachta | 895811 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: drenážní šachta; Stavební výrobek: nerelevantni; Specifikace: plast DN600 s kalníkem; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
odvodnění-drenážní šachta | 3.07248 | 2 | yes | ((-640781.861057633,-1063743.80908663,236.851275989758),(-640781.261057633,-1063743.20908663,238.181275989758)) | ByLayer | 5 | odvodnění-drenážní šachta | Barva_5 |  |  |  |  | P100 | 0;0;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 3031.79 | 3031.79 | drenážní šachta | 895811 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: drenážní šachta; Stavební výrobek: nerelevantni; Specifikace: plast DN600 s kalníkem; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
odvodnění-drenážní šachta | 3.07248 | 2 | yes | ((-640867.882508892,-1063692.70288851,237.755363894904),(-640867.282508892,-1063692.10288851,239.085363894904)) | ByLayer | 5 | odvodnění-drenážní šachta | Barva_5 |  |  |  |  | P100 | 0;0;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2932.27 | 2932.27 | drenážní šachta | 895811 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: drenážní šachta; Stavební výrobek: nerelevantni; Specifikace: plast DN600 s kalníkem; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
odvodnění-drenážní šachta | 3.07248 | 2 | yes | ((-640872.119462791,-1063701.7608911,237.755365111041),(-640871.519462791,-1063701.1608911,239.085365111041)) | ByLayer | 5 | odvodnění-drenážní šachta | Barva_5 |  |  |  |  | P100 | 0;0;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2932.27 | 2932.27 | drenážní šachta | 895811 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: drenážní šachta; Stavební výrobek: nerelevantni; Specifikace: plast DN600 s kalníkem; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
odvodnění-drenážní šachta | 3.07248 | 2 | yes | ((-641049.043295064,-1063607.96346702,237.746261173627),(-641048.443295064,-1063607.36346702,239.076261173627)) | ByLayer | 5 | odvodnění-drenážní šachta | Barva_5 |  |  |  |  | P100 | 0;0;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2732.27 | 2732.27 | drenážní šachta | 895811 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: drenážní šachta; Stavební výrobek: nerelevantni; Specifikace: plast DN600 s kalníkem; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
odvodnění-drenážní šachta | 3.07248 | 2 | yes | ((-641053.280266152,-1063617.02150636,237.74626117332),(-641052.680266152,-1063616.42150636,239.07626117332)) | ByLayer | 5 | odvodnění-drenážní šachta | Barva_5 |  |  |  |  | P100 | 0;0;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2732.27 | 2732.27 | drenážní šachta | 895811 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: drenážní šachta; Stavební výrobek: nerelevantni; Specifikace: plast DN600 s kalníkem; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
odvodnění-drenážní šachta | 3.07248 | 2 | yes | ((-641139.623688148,-1063565.59375628,236.755361743025),(-641139.023688148,-1063564.99375628,238.085361743024)) | ByLayer | 5 | odvodnění-drenážní šachta | Barva_5 |  |  |  |  | P100 | 0;0;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2632.27 | 2632.27 | drenážní šachta | 895811 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: drenážní šachta; Stavební výrobek: nerelevantni; Specifikace: plast DN600 s kalníkem; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
odvodnění-drenážní šachta | 3.07248 | 2 | yes | ((-641143.860659236,-1063574.65179561,236.755361743365),(-641143.260659236,-1063574.05179561,238.085361743365)) | ByLayer | 5 | odvodnění-drenážní šachta | Barva_5 |  |  |  |  | P100 | 0;0;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2632.27 | 2632.27 | drenážní šachta | 895811 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: drenážní šachta; Stavební výrobek: nerelevantni; Specifikace: plast DN600 s kalníkem; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
odvodnění-drenážní šachta | 3.07248 | 2 | yes | ((-641213.899610488,-1063530.85059346,235.577346193725),(-641213.299610488,-1063530.25059346,236.907346193725)) | ByLayer | 5 | odvodnění-drenážní šachta | Barva_5 |  |  |  |  | P100 | 0;0;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2550.27 | 2550.27 | drenážní šachta | 895811 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: drenážní šachta; Stavební výrobek: nerelevantni; Specifikace: plast DN600 s kalníkem; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
odvodnění-drenážní šachta | 3.07248 | 2 | yes | ((-641218.136581563,-1063539.9086328,235.564146624933),(-641217.536581563,-1063539.3086328,236.894146624933)) | ByLayer | 5 | odvodnění-drenážní šachta | Barva_5 |  |  |  |  | P100 | 0;0;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2550.27 | 2550.27 | drenážní šachta | 895811 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: drenážní šachta; Stavební výrobek: nerelevantni; Specifikace: plast DN600 s kalníkem; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
odvodnění-drenážní šachta | 4.15947 | 2 | yes | ((-640962.799855875,-1063659.49118036,238.07974819651),(-640961.999855875,-1063658.69118036,239.40974819651)) | ByLayer | 5 | odvodnění-drenážní šachta | Barva_5 |  |  |  |  | P100 | 0;0;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2832.36 | 2832.36 | drenážní šachta | 895812 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: drenážní šachta; Stavební výrobek: nerelevantni; Specifikace: plast DN800 s kalníkem; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
odvodnění-drenážní šachta | 4.15947 | 2 | yes | ((-640958.562901977,-1063650.43317777,238.079746980373),(-640957.762901977,-1063649.63317777,239.409746980373)) | ByLayer | 5 | odvodnění-drenážní šachta | Barva_5 |  |  |  |  | P100 | 0;0;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2832.36 | 2832.36 | drenážní šachta | 895812 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: drenážní šachta; Stavební výrobek: nerelevantni; Specifikace: plast DN800 s kalníkem; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-výkop_odkop | 7126.85 | 1 | no | ((-642481.827823387,-1063506.39429476,229.9),(-641293.21371822,-1062931.43237372,233.694364966988)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 594.378 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1150 | 2459.7 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-násyp | 1547.51 | 2 | yes | ((-640776.624763706,-1063774.63227028,235.26067900388),(-640730.333751098,-1063735.17052172,237.503453539537)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 433.26 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3038.7 | 3080.23 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-výkop_odkop | 1706.11 | 1 | no | ((-640776.383070915,-1063808.56882651,232.303622464568),(-640643.237493055,-1063735.62364908,237.260647761804)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 220.836 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3038.72 | 3180 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 1339.1 | 1 | no | ((-642531.150855659,-1062938.98635746,231.30626851051),(-642478.816392849,-1062907.91426355,233.176021880432)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 262.75 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1100 | 1150 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-násyp | 2011.84 | 1 | no | ((-641302.637862062,-1063753.52620829,233.03),(-640769.411348823,-1063490.57153007,241.871261107961)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 353.964 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2459.44 | 3039.18 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-výkop_odkop | 25507.9 | 1 | no | ((-641302.501051586,-1063749.55579937,233.436776229204),(-640769.6539655,-1063487.12403117,243.88)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 30933.9 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2459.45 | 3039.16 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-výkop_odkop | 5770.78 | 1 | no | ((-642355.181682916,-1063111.51296016,229.951896017441),(-642143.096981133,-1062992.78926159,232.492647990069)) | ByLayer | 36 | zemní práce-výkop_odkop | Barva_36 |  |  |  |  | P100 | 125;75;0 | 2493.11 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1290 | 1529.5 | výkop/odkop | 12373 | I1+S1+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-aktivní zóna | 35457.8 | 1 | no | ((-642485.014550026,-1063794.78829038,230.392521930914),(-640637.949388326,-1062932.06842865,237.626678859756)) | ByLayer | 256 | zemní práce-aktivní zóna | ByLayer | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 128;0;0 | 8118.34 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1150 | 3180 | aktivní zóna | 17180 | I1+S1+E1+Z1+M3+F1
záchytné systémy-svodidlo | 80.852 | 2 | yes | ((-640736.712974791,-1063789.8993868,237.677141753715),(-640652.475491489,-1063762.44922941,238.620108443601)) | ByLayer | 4 | záchytné systémy-svodidlo | Barva_4 |  |  |  |  | P2 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | záchytné systémy | 3079.99 | 3168 | svodidlo | 9113A1 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: svodidlo; Stavební výrobek: ocelové svodidlo N2; Specifikace: TP 203; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 88.01
záchytné systémy-svodidlo | 79.7435 | 2 | yes | ((-640733.171877057,-1063780.6227409,237.476337577721),(-640650.09202064,-1063753.54975252,238.406524275289)) | ByLayer | 4 | záchytné systémy-svodidlo | Barva_4 |  |  |  |  | P2 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | záchytné systémy | 3080.01 | 3168 | svodidlo | 9113A1 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: svodidlo; Stavební výrobek: ocelové svodidlo N2; Specifikace: TP 203; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 87.99
vozovka_chodník-obrusná vrstva | 0.0024 | 2 | no | ((-640639.66564821,-1063788.11443416,237.098276054439),(-640639.639195484,-1063788.08766379,237.11887484559)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.000008 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3179.98 | 3180 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-podkladní asfaltová vrstva | 0.0024 | 2 | no | ((-640639.66564821,-1063788.11443416,236.998276054439),(-640639.639195484,-1063788.08766379,237.01887484559)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.000008 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3179.98 | 3180 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 0.0024 | 2 | no | ((-640639.66564821,-1063788.11443416,237.058276054439),(-640639.639195484,-1063788.08766379,237.07887484559)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.000008 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3179.98 | 3180 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-horní podkladní vrstva | 0.0024 | 2 | no | ((-640639.66564821,-1063788.11443416,236.928276054439),(-640639.639195484,-1063788.08766379,236.94887484559)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.000008 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3179.98 | 3180 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 0.0024 | 2 | no | ((-640639.66564821,-1063788.11443416,236.728276054439),(-640639.639195484,-1063788.08766379,236.74887484559)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 0.000008 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3179.98 | 3180 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642507.310291045,-1062921.39843835,232.550916567766),(-642507.210291045,-1062921.29843835,233.300916567766)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1120.05 | 1120.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642462.27728171,-1062943.12464534,232.300135921516),(-642462.17728171,-1062943.02464534,233.050135921516)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1170.05 | 1170.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642417.244272376,-1062964.85085234,232.049355275259),(-642417.144272376,-1062964.75085234,232.799355275259)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1220.05 | 1220.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642372.211263041,-1062986.57705933,231.798574629009),(-642372.111263041,-1062986.47705933,232.548574629009)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1270.05 | 1270.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642327.178253706,-1063008.30326632,0),(-642327.078253706,-1063008.20326632,0.75)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1320.05 | 1320.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642282.145244372,-1063030.02947331,0),(-642282.045244372,-1063029.92947331,0.75)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1370.05 | 1370.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642237.11274769,-1063051.75539053,0),(-642237.01274769,-1063051.65539053,0.75)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1420.05 | 1420.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642192.012085571,-1063073.23006722,0),(-642191.912085571,-1063073.13006722,0.75)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1470.05 | 1470.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642146.733583572,-1063094.41902388,232.014131473903),(-642146.633583571,-1063094.31902388,232.764131473903)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1520.05 | 1520.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642101.443387027,-1063115.60387925,232.266134858124),(-642101.343387027,-1063115.50387925,233.016134858124)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1570.05 | 1570.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642056.153190483,-1063136.78873462,232.518138242341),(-642056.053190483,-1063136.68873462,233.268138242341)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1620.05 | 1620.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642010.862993939,-1063157.97358998,232.755081525046),(-642010.762993939,-1063157.87358998,233.505081525046)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1670.05 | 1670.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641965.572797395,-1063179.15844535,232.915050955484),(-641965.472797395,-1063179.05844535,233.665050955484)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1720.05 | 1720.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641920.282600851,-1063200.34330072,232.991353155223),(-641920.182600851,-1063200.24330072,233.741353155223)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1770.05 | 1770.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641874.992404307,-1063221.52815609,232.983988124288),(-641874.892404307,-1063221.42815609,233.733988124288)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1820.05 | 1820.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641829.702207763,-1063242.71301146,232.892955862603),(-641829.602207763,-1063242.61301146,233.642955862603)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1870.05 | 1870.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641784.412011219,-1063263.89786683,232.718256370236),(-641784.312011219,-1063263.79786683,233.468256370236)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1920.05 | 1920.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641739.121814674,-1063285.0827222,232.474949748714),(-641739.021814674,-1063284.9827222,233.224949748714)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1970.05 | 1970.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641693.83161813,-1063306.26757757,232.224949748692),(-641693.73161813,-1063306.16757757,232.974949748692)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2020.05 | 2020.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641648.541421586,-1063327.45243293,231.975088804726),(-641648.441421586,-1063327.35243293,232.725088804726)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2070.05 | 2070.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641603.251225042,-1063348.6372883,231.606451636175),(-641603.151225042,-1063348.5372883,232.356451636175)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2120.05 | 2120.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641557.961028498,-1063369.82214367,231.624134525777),(-641557.861028498,-1063369.72214367,232.374134525777)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2170.05 | 2170.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641512.670831954,-1063391.00699904,231.815637473594),(-641512.570831954,-1063390.90699904,232.565637473594)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2220.05 | 2220.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641467.38063541,-1063412.19185441,232.180960479565),(-641467.28063541,-1063412.09185441,232.930960479565)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2270.05 | 2270.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641422.090438866,-1063433.37670978,232.720103543734),(-641421.990438866,-1063433.27670978,233.470103543734)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2320.05 | 2320.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641376.800242322,-1063454.56156515,233.43306666612),(-641376.700242322,-1063454.46156515,234.18306666612)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2370.05 | 2370.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641331.510045778,-1063475.74642052,234.317624949911),(-641331.410045777,-1063475.64642052,235.067624949911)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2420.05 | 2420.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641277.161809925,-1063501.16824696,235.452683350271),(-641277.061809924,-1063501.06824696,236.202683350271)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2480.05 | 2480.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641231.87161338,-1063522.35310233,236.398565350608),(-641231.77161338,-1063522.25310233,237.148565350608)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2530.05 | 2530.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641186.581416836,-1063543.5379577,237.304171471431),(-641186.481416836,-1063543.4379577,238.054171471431)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2580.05 | 2580.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641141.291220292,-1063564.72281306,238.052783857803),(-641141.191220292,-1063564.62281306,238.802783857803)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2630.05 | 2630.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641096.001023748,-1063585.90766843,238.637004899214),(-641095.901023748,-1063585.80766843,239.387004899214)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2680.05 | 2680.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641050.710827204,-1063607.0925238,239.056834595656),(-641050.610827204,-1063606.9925238,239.806834595656)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2730.05 | 2730.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-641005.42063066,-1063628.27737917,239.312272947132),(-641005.32063066,-1063628.17737917,240.062272947132)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2780.05 | 2780.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-640960.130434116,-1063649.46223454,239.403319953643),(-640960.030434116,-1063649.36223454,240.153319953643)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2830.05 | 2830.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-640914.840237572,-1063670.64708991,239.329975615184),(-640914.740237572,-1063670.54708991,240.079975615184)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2880.05 | 2880.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-640869.550041027,-1063691.83194528,239.092239931757),(-640869.450041027,-1063691.73194528,239.842239931757)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2930.05 | 2930.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-640824.259844483,-1063713.01680065,238.690112903386),(-640824.159844483,-1063712.91680065,239.440112903386)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 2980.05 | 2980.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-640778.959899541,-1063734.05588998,238.19017471227),(-640778.859899541,-1063733.95588998,238.94017471227)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3030.05 | 3030.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-640733.228276653,-1063753.66980766,237.689416909392),(-640733.128276653,-1063753.56980766,238.439416909392)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3080.05 | 3080.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.109956 | 2 | yes | ((-640705.299364701,-1063764.04776101,238.211714306708),(-640705.199364701,-1063763.94776101,238.511714306708)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3110.05 | 3110.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.109956 | 2 | yes | ((-640676.952068054,-1063773.21956807,237.989934631737),(-640676.852068053,-1063773.11956807,238.289934631737)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3140.05 | 3140.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.109956 | 2 | yes | ((-640648.237843526,-1063781.16844106,237.822823273662),(-640648.137843526,-1063781.06844106,238.122823273662)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 3170.05 | 3170.05 | svislé dopravní značení | 91238 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642511.438270374,-1062929.95471013,232.550916567894),(-642511.338270373,-1062929.85471013,233.300916567894)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1120.05 | 1120.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642466.405261039,-1062951.68091712,232.300135921616),(-642466.305261039,-1062951.58091712,233.050135921616)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1170.05 | 1170.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642421.372251704,-1062973.40712411,232.049355275346),(-642421.272251704,-1062973.30712411,232.799355275346)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1220.05 | 1220.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642376.33924237,-1062995.1333311,231.798574629068),(-642376.239242369,-1062995.0333311,232.548574629068)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1270.05 | 1270.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
dopravní značení-svislé dopravní značení-sloupky bile | 0.251327 | 2 | yes | ((-642331.306233035,-1063016.85953809,231.547793982804),(-642331.206233035,-1063016.75953809,232.297793982804)) | ByLayer | 7 | dopravní značení-svislé dopravní značení-sloupky bile | Barva_7 |  |  |  |  | P10 | 255;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | dopravní značení | 1320.05 | 1320.05 | svislé dopravní značení | 91228 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.6; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: SDZ; Stavební výrobek: směrový sloupek; Specifikace: Z11a,b; Podrobná specifikace: TP 65; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
