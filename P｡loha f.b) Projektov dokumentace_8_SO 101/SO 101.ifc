Properties of the parts of a building model (IFC4X3_ADD2), part 11 of 21

# IfcBuiltElement (2093)
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | Linetype | ColorIndex | Layer | PlotStyleName | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | Skupina elementů | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Tloušťka
vozovka_chodník-ložní vrstva | 0.0102671 | 1 | no | ((-640806.306461513,-1063721.89121288,238.428092655139),(-640806.263819137,-1063721.80002183,238.490608945102)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.36642e-07 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-obrusná vrstva | 4.64664 | 1 | no | ((-640806.261140276,-1063740.23872467,238.047843252451),(-640766.234155644,-1063721.89401495,238.530107590162)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.017713 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3043.88 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 0.000815046 | 1 | no | ((-640806.306461513,-1063721.89121288,238.490102148761),(-640806.297845667,-1063721.87284421,238.530608945102)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.83714e-08 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
odvodnění-zpevněné příkopy a odvodňovací žlaby | 768.639 | 1 | no | ((-641209.715405699,-1063750.04375582,236.100000000011),(-640774.861771615,-1063545.19618811,239.079280109905)) | ByLayer | 8 | odvodnění-zpevněné příkopy a odvodňovací žlaby | Barva_8 |  |  |  |  | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2560 | 3040 | zpevněné příkopy a odvodňovací žlaby | nerelevantni | nerelevantni | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: rigol; Stavební výrobek: lože; Specifikace: C20/25nXF3; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 480
zemní práce-zemní krajnice a dosypávky | 136.94 | 1 | no | ((-640810.482656597,-1063748.17122637,237.427925522015),(-640773.563864531,-1063729.77740681,238.365172782287)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 9.93308 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3000.05 | 3040 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 0.335331 | 1 | no | ((-640810.556413859,-1063730.9867911,237.993288403032),(-640809.981380215,-1063729.75621487,238.365673884811)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D.1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.00000782 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3000 | 3000 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 103.675 | 1 | no | ((-640810.375885876,-1063747.4335663,237.912604601153),(-640773.489837918,-1063729.61320743,238.530151151436)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 5.34735 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3040 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-zpevnění krajnic | 0.267284 | 1 | no | ((-640810.421257811,-1063730.69755464,238.282552744012),(-640809.904657647,-1063729.59201594,238.530652254027)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.000006233 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 88.2043 | 1 | no | ((-640811.405991883,-1063750.69236844,236.897907618172),(-640775.124963317,-1063731.34939352,239.123485511127)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 5.61745 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3000.05 | 3040 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 121.01 | 1 | no | ((-640810.420804637,-1063749.44373481,236.892800193185),(-640773.781431204,-1063730.2613362,238.322440844428)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 7.06941 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3000.05 | 3040 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 104.76 | 1 | no | ((-640810.330601319,-1063747.39822773,237.453320808433),(-640773.489837918,-1063729.61320743,238.160151151498)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 10.1157 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3040 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 0.719037 | 1 | no | ((-640810.728108174,-1063731.35424521,237.831053284308),(-640809.904657647,-1063729.59201594,238.160652254027)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 0.0000167662 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-horní podkladní vrstva | 58.5374 | 1 | no | ((-640810.112378108,-1063746.86168622,237.780142632489),(-640773.489837918,-1063729.61320743,238.360151151452)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 3.53629 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3040 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 0.176836 | 1 | no | ((-640810.157746797,-1063730.13359767,238.145707680526),(-640809.904657647,-1063729.59201594,238.360652254027)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.00000412389 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-podkladní asfaltová vrstva | 19.4759 | 1 | no | ((-640809.938103457,-1063746.48891584,237.987400788243),(-640773.489837918,-1063729.61320743,238.430151151438)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.471614 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3040 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 0.0235923 | 1 | no | ((-640809.983469998,-1063729.76061662,238.355999888342),(-640809.904657647,-1063729.59201594,238.430652254027)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 5.49857e-07 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | podkladní asfaltová vrstva | 574E06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 11.9707 | 1 | no | ((-640809.901933969,-1063746.41101057,238.058917670113),(-640773.489837918,-1063729.61320743,238.490151151431)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.205145 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3040 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 0.0102671 | 1 | no | ((-640809.947300064,-1063729.68320701,238.428135964242),(-640809.904657647,-1063729.59201594,238.490652254027)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.36456e-07 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-obrusná vrstva | 4.22434 | 1 | no | ((-640809.867907857,-1063746.33771205,238.120344854572),(-640773.489837918,-1063729.61320743,238.530151151431)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0162124 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000.05 | 3040 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 0.000815051 | 1 | no | ((-640809.913273534,-1063729.61038463,238.490145457973),(-640809.904657647,-1063729.59201594,238.530652254027)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.83898e-08 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3000 | 3000 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-zpevnění krajnic | 3.70718 | 1 | no | ((-642508.065629327,-1062933.2785886,232.311361392694),(-642506.052616494,-1062931.20838071,232.570670538555)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.16 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1124 | 1127 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 2321.7 | 2 | yes | ((-642497.986865295,-1063008.00706564,229.482956460997),(-642362.984951756,-1062937.12365206,232.354840935161)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 165.406 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1136.17 | 1284.8 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 43.2501 | 2 | no | ((-642282.087341392,-1063041.18427587,230.634564616328),(-642259.803904751,-1063030.08810435,231.070885129272)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 4.59375 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1370.25 | 1394.75 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrubník | 153.075 | 1 | no | ((-642358.831492278,-1063078.60749148,231.14447064549),(-642180.315935234,-1062992.82291757,231.985790956065)) | ByLayer | 40 | vozovka_chodník-obrubník | Barva_40 |  |  |  |  | P2 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1284.8 | 1482.8 | obrubník | 917224 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obrubník; Stavební výrobek: silniční 15/25/100; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 198
vozovka_chodník-obrubník | 223.574 | 1 | no | ((-642358.831492278,-1063078.60749148,231.00947064549),(-642180.248143697,-1062992.67881194,231.885790956065)) | ByLayer | 40 | vozovka_chodník-obrubník | Barva_40 |  |  |  |  | P2 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1284.8 | 1482.8 | obrubník | nerelevantni | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obrubník; Stavební výrobek: lože; Specifikace: C20/25nXF3; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 0
vozovka_chodník-spodní podkladní vrstva | 271.414 | 1 | no | ((-642358.831492278,-1063078.60749148,230.63447064549),(-642180.248143697,-1062992.67881194,231.600790956065)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 23.0107 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1284.8 | 1482.8 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 103.377 | 1 | no | ((-642508.310968209,-1062943.67527158,232.393669102565),(-642497.265940396,-1062931.43635305,232.57)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.2 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 125;75;0 | 3.03184 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1124.56 | 1135.44 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-horní podkladní vrstva | 102.998 | 1 | no | ((-642508.310968209,-1062943.67527158,232.343669102565),(-642497.265940396,-1062931.43635305,232.51)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklvaný materiál | TP210 | P2 | 128;128;128 | 2.52654 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1124.56 | 1135.44 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-obrusná vrstva | 1.76901 | 1 | no | ((-642508.337988014,-1062941.93717502,232.45366910256),(-642505.641683151,-1062931.66151809,232.57)) | ByLayer | 36 | vozovka_chodník-obrusná vrstva | Barva_36 | nerelevantni | D.1.1.2 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 125;75;0 | 0.0101196 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1124.55 | 1128 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-horní podkladní vrstva | 3.26713 | 1 | no | ((-642508.405537528,-1062941.93717502,232.40366910256),(-642505.641683151,-1062931.66151809,232.51)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklvaný materiál | TP210 | P2 | 128;128;128 | 0.0517922 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1124.53 | 1128 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-zpevnění krajnic | 12.8852 | 1 | no | ((-642508.761298302,-1062941.93717502,232.373349612928),(-642505.641683151,-1062931.66151809,232.57)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.493467 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1124.41 | 1128 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 1.76901 | 1 | no | ((-642504.708327462,-1062943.6883073,232.393669102565),(-642497.374571431,-1062936.34572408,232.51)) | ByLayer | 36 | vozovka_chodník-obrusná vrstva | Barva_36 | nerelevantni | D.1.1.2 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 125;75;0 | 0.0101196 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1132 | 1135.45 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-horní podkladní vrstva | 3.26713 | 1 | no | ((-642504.708327462,-1062943.72089661,232.343669102565),(-642497.374571431,-1062936.34572408,232.45)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklvaný materiál | TP210 | P2 | 128;128;128 | 0.0517922 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1132 | 1135.47 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-zpevnění krajnic | 12.8852 | 1 | no | ((-642504.708327462,-1062943.89253365,232.313349612933),(-642497.374571431,-1062936.34572408,232.51)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.493467 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1132 | 1135.59 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 77.9863 | 1 | no | ((-642509.705524035,-1062943.89253365,231.509963932417),(-642497.053993385,-1062931.88387585,232.71)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 4.98026 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1124.03 | 1136.04 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 238.973 | 2 | yes | ((-642531.355945584,-1062935.70650195,231.50796783575),(-642507.846255817,-1062921.40821909,232.9320175414)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 16.6076 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1100 | 1124.04 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
propustky-zpevnění dlažbou | 19.7867 | 1 | no | ((-642509.13646998,-1062939.69788427,231.42),(-642497.61878104,-1062933.0867753,232.472514522924)) | ByLayer | 8 | propustky-zpevnění dlažbou | Barva_8 | nerelevantni | D.1.1.4 | lomový kámen, spárováno MC | nerelevantni | P50 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 1124.04 | 1136.03 | zpevnění dlažbou | 465512 | I1+S1+E1+Z1+M2+F1 | CZ_M2 - Způsob stanovení plochy: 3D plocha TIN povrchu; Plocha: 8.2526
propustky-lože | 17.3401 | 1 | no | ((-642509.13646998,-1062939.69788427,231.32),(-642497.61878104,-1062933.0867753,232.272514522924)) | ByLayer | 16 | propustky-lože | Barva_16 | nerelevantni | D.1.1.4 | beton | nerelevantni | P50 | 128;0;0 | 0.694908 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 1124.04 | 1136.03 | lože | 45131A | I1+S1;4+E1+Z1+M3+F1 | CZ_S4 - Specifikace: nerelevantni; Beton: C20/25nXF3; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.1.4; Návrhová životnost: 25
propustky-propust | 31.5854 | 1 | no | ((-642507.927870526,-1062938.62393899,231.62010672794),(-642498.881454636,-1062934.09411953,232.24871567031)) | ByLayer | 8 | propustky-propust | Barva_8 | nerelevantni | D.1.1.4 | PP | nerelevantni | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 1125.03 | 1135 | propust | 87458 | I1+S1;2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: nerelevantni; Stavební výrobek: nerelevantni; Specifikace: PP SN16 DN600; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 9.97
propustky-obetonování | 31.4216 | 1 | no | ((-642508.153766198,-1062938.93763934,231.47),(-642498.604177808,-1062933.68584469,231.949360294651)) | ByLayer | 8 | propustky-obetonování | Barva_8 | nerelevantni | D.1.1.4 | beton C20/25nXF3 | nerelevantni | P50 | 128;128;128 | 2.99114 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 1125.03 | 1135.03 | obetonování | 89952A | I1+S1+E1+Z1+M3+F1
propustky-podkladní vrstva | 33.1548 | 1 | no | ((-642508.239955205,-1062939.27678441,231.369999999986),(-642498.517988801,-1062933.50536905,231.503025506538)) | ByLayer | 2 | propustky-podkladní vrstva | Barva_2 | nerelevantni | D.1.1.4 | štěrkodrť fr. 0/32 | nerelevantni | P50 | 255;255;0 | 1.48325 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 1125.03 | 1135.04 | podkladní vrstva | 45152 | I1+S1+E1+Z1+M3+F1
propustky-zásypy a obsypy | 25.0751 | 1 | no | ((-642507.627959593,-1062937.99529503,231.37),(-642498.479004845,-1062933.41516046,232.218306030722)) | ByLayer | 40 | propustky-zásypy a obsypy | Barva_40 | vhodná nebo podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P50 | 255;165;0 | 2.88605 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 1125.03 | 1135.03 | zásypy a obsypy | 17511 | I1+S1;3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
vozovka_chodník-spodní podkladní vrstva | 109.821 | 1 | no | ((-642508.310968209,-1062943.67527158,232.113669102565),(-642497.265940396,-1062931.43635305,232.46)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 11.6221 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1124.56 | 1135.44 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
vozovka_chodník-spodní podkladní vrstva | 15.52 | 1 | no | ((-642508.806331311,-1062941.93717502,232.17366910256),(-642505.641683151,-1062931.66151809,232.46)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 0.955416 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1124.39 | 1128 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
vozovka_chodník-spodní podkladní vrstva | 15.52 | 1 | no | ((-642504.708327462,-1062943.91425985,232.113669102565),(-642497.374571431,-1062936.34572408,232.4)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 0.955416 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1132 | 1135.61 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
objekty na TV-uliční vpusť | 2.26199 | 2 | yes | ((-642282.537671485,-1063030.53843444,230.117013336502),(-642281.870079322,-1063029.87084228,231.297013336502)) | ByLayer | 4 | objekty na TV-uliční vpusť | Barva_4 |  |  |  |  | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | objekty na TV | 1369.75 | 1370.25 | uliční vpusť | 89712 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: uliční vpusť; Stavební výrobek: nerelevantni; Specifikace: mříž D400, bet. dílce DN450, přípojka DN150; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-podkladní a výplňové vrstvy | 1.605 | 2 | yes | ((-642282.704569526,-1063030.70533249,229.957013336502),(-642281.703181281,-1063029.70394424,230.117013336502)) | ByLayer | 8 | zemní práce-podkladní a výplňové vrstvy | Barva_8 |  |  |  |  | P100 | 128;128;128 | 0.09 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1369.63 | 1370.38 | podkladní a výplňové vrstvy | 45157 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: ŠP
objekty na TV-uliční vpusť | 2.26199 | 2 | yes | ((-642260.021166821,-1063041.40153794,230.054471017192),(-642259.353574658,-1063040.73394577,231.234471017192)) | ByLayer | 4 | objekty na TV-uliční vpusť | Barva_4 |  |  |  |  | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | objekty na TV | 1394.75 | 1395.25 | uliční vpusť | 89712 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: uliční vpusť; Stavební výrobek: nerelevantni; Specifikace: mříž D400, bet. dílce DN450, přípojka DN150; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-podkladní a výplňové vrstvy | 1.605 | 2 | yes | ((-642260.188064862,-1063041.56843598,229.894471017192),(-642259.186676617,-1063040.56704773,230.054471017192)) | ByLayer | 8 | zemní práce-podkladní a výplňové vrstvy | Barva_8 |  |  |  |  | P100 | 128;128;128 | 0.09 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1394.62 | 1395.38 | podkladní a výplňové vrstvy | 45157 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: ŠP
objekty na TV-uliční vpusť | 2.26199 | 2 | yes | ((-642237.994603103,-1063052.02826846,230.117013336502),(-642237.32701094,-1063051.3606763,231.297013336502)) | ByLayer | 4 | objekty na TV-uliční vpusť | Barva_4 |  |  |  |  | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | objekty na TV | 1419.21 | 1419.71 | uliční vpusť | 89712 | I1+S2+E1+Z1+M4+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: uliční vpusť; Stavební výrobek: nerelevantni; Specifikace: mříž D400, bet. dílce DN450, přípojka DN150; Podrobná specifikace: nerelevantni; CZ_M4 - Počet: 1; Způsob stanovení počtu: odečet z modelu
zemní práce-podkladní a výplňové vrstvy | 1.605 | 2 | yes | ((-642238.161501144,-1063052.1951665,229.957013336502),(-642237.160112899,-1063051.19377826,230.117013336502)) | ByLayer | 8 | zemní práce-podkladní a výplňové vrstvy | Barva_8 |  |  |  |  | P100 | 128;128;128 | 0.09 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1419.08 | 1419.83 | podkladní a výplňové vrstvy | 45157 | I1+S3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: ŠP
trubní vedení-podsyp | 12.6213 | 1 | no | ((-642287.301730035,-1063040.51661401,230.230167577508),(-642282.154890909,-1063030.35376168,230.625)) | ByLayer | 2 | trubní vedení-podsyp | Barva_2 | nerelevantni | D.1.1.4 | ŠP | nerelevantni | P50 | 255;255;0 | 0.574699 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 1369.82 | 1370.17 | podsyp | 45157 | I1+S1+E1+Z1+M3+F1
trubní vedení-obsyp | 12.4619 | 1 | no | ((-642287.199306011,-1063040.30826434,230.409827748818),(-642282.154890909,-1063030.35376168,230.8)) | ByLayer | 40 | trubní vedení-obsyp | Barva_40 |  |  |  |  | P50 | 255;165;0 | 0.571072 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 1369.82 | 1370.17 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | 0.3 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: ŠP; Stavební výrobek: nerelevantni; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni
trubní vedení-podsyp | 12.3164 | 1 | no | ((-642264.667660515,-1063051.14006262,230.275027038877),(-642259.638386242,-1063041.21686518,230.555)) | ByLayer | 2 | trubní vedení-podsyp | Barva_2 | nerelevantni | D.1.1.4 | ŠP | nerelevantni | P50 | 255;255;0 | 0.560779 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 1394.83 | 1395.18 | podsyp | 45157 | I1+S1+E1+Z1+M3+F1
trubní vedení-obsyp | 12.1597 | 1 | no | ((-642264.567557124,-1063050.93249531,230.452256974494),(-642259.638386242,-1063041.21686518,230.73)) | ByLayer | 40 | trubní vedení-obsyp | Barva_40 |  |  |  |  | P50 | 255;165;0 | 0.557156 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 1394.83 | 1395.18 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | 0.3 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: ŠP; Stavební výrobek: nerelevantni; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni
trubní vedení-podsyp | 12.2043 | 1 | no | ((-642242.599770113,-1063061.68345338,230.373134278633),(-642237.611826992,-1063051.84358644,230.615)) | ByLayer | 2 | trubní vedení-podsyp | Barva_2 | nerelevantni | D.1.1.4 | ŠP | nerelevantni | P50 | 255;255;0 | 0.555602 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 1419.28 | 1419.63 | podsyp | 45157 | I1+S1+E1+Z1+M3+F1
trubní vedení-obsyp | 12.0374 | 1 | no | ((-642242.494807949,-1063061.46207456,230.54966212502),(-642237.611826992,-1063051.84358644,230.79)) | ByLayer | 40 | trubní vedení-obsyp | Barva_40 |  |  |  |  | P50 | 255;165;0 | 0.551512 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 1419.28 | 1419.63 | obsyp | 17581 | I1+S2+E1+Z1+M3;2&6+F1 | 0.3 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: ŠP; Stavební výrobek: nerelevantni; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni
propustky-zpevnění dlažbou | 9.22819 | 1 | no | ((-642287.929806075,-1063062.49830806,230.053499999996),(-642241.886901986,-1063040.01496055,230.773062979609)) | ByLayer | 8 | propustky-zpevnění dlažbou | Barva_8 | nerelevantni | D.1.1.4 | lomový kámen, spárováno MC | nerelevantni | P50 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 1369.5 | 1419.95 | zpevnění dlažbou | 465512 | I1+S1+E1+Z1+M2+F1 | CZ_M2 - Způsob stanovení plochy: 3D plocha TIN povrchu; Plocha: 3.41191
propustky-lože | 7.60918 | 1 | no | ((-642287.929806075,-1063062.49830806,229.953499999996),(-642241.886901986,-1063040.01496055,230.573062979609)) | ByLayer | 16 | propustky-lože | Barva_16 | nerelevantni | D.1.1.4 | beton | nerelevantni | P50 | 128;0;0 | 0.296754 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 1369.5 | 1419.95 | lože | 45131A | I1+S1;4+E1+Z1+M3+F1 | CZ_S4 - Specifikace: nerelevantni; Beton: C20/25nXF3; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.1.4; Návrhová životnost: 25
trubní vedení-potrubí | 10.4203 | 1 | no | ((-642287.394992881,-1063040.91699569,230.32),(-642282.244956928,-1063030.3972141,230.7)) | ByLayer | 4 | trubní vedení-potrubí | Barva_4 | nerelevantni | D.1.1.4 | PP SN 12 DN150 | nerelevantni | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 1369.92 | 1370.07 | potrubí | 87 433 | I1+S1+E1+Z1+M1+F1 | CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 11.4
trubní vedení-potrubí | 10.168 | 1 | no | ((-642264.75608727,-1063051.52835646,230.370071358572),(-642259.72845226,-1063041.26031759,230.63)) | ByLayer | 4 | trubní vedení-potrubí | Barva_4 | nerelevantni | D.1.1.4 | PP SN 12 DN150 | nerelevantni | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 1394.93 | 1395.08 | potrubí | 87 433 | I1+S1+E1+Z1+M1+F1 | CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 11.1
trubní vedení-potrubí | 10.0795 | 1 | no | ((-642242.687127642,-1063062.06608454,230.47),(-642237.701890459,-1063051.88704415,230.69)) | ByLayer | 4 | trubní vedení-potrubí | Barva_4 | nerelevantni | D.1.1.4 | PP SN 12 DN150 | nerelevantni | P10 | 0;255;255 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | trubní vedení | 1419.38 | 1419.53 | potrubí | 87 433 | I1+S1+E1+Z1+M1+F1 | CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 11
propustky-zásypy a obsypy | 1.76493 | 1 | no | ((-642501.729944873,-1062938.53893368,232.158556012222),(-642499.423526086,-1062936.8547565,232.330421436275)) | ByLayer | 40 | propustky-zásypy a obsypy | Barva_40 | vhodná nebo podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P50 | 255;165;0 | 0.048122 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 1132.39 | 1133.89 | zásypy a obsypy | 17511 | I1+S1;3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
propustky-zásypy a obsypy | 1.12092 | 1 | no | ((-642506.417368106,-1062936.30329437,232.237596757931),(-642505.984959669,-1062933.71718718,232.350035580547)) | ByLayer | 40 | propustky-zásypy a obsypy | Barva_40 | vhodná nebo podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P50 | 255;165;0 | 0.0196117 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 1126.14 | 1127.54 | zásypy a obsypy | 17511 | I1+S1;3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
propustky-zásypy a obsypy | 22.5004 | 1 | no | ((-642508.290121964,-1062939.29042931,231.37),(-642499.198345286,-1062934.78685843,232.210100732476)) | ByLayer | 40 | propustky-zásypy a obsypy | Barva_40 | vhodná nebo podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P50 | 255;165;0 | 2.44968 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 1125.03 | 1135.04 | zásypy a obsypy | 17511 | I1+S1;3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
vozovka_chodník-spodní podkladní vrstva | 42.2981 | 1 | no | ((-642259.570836728,-1063051.81100689,230.634599770044),(-642237.777341033,-1063040.95120784,231.068760574061)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 4.49175 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1395.25 | 1419.21 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 149.039 | 1 | no | ((-642359.048754348,-1063030.32117237,230.698267239723),(-642282.320409415,-1062992.9580166,231.499343557747)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 15.9281 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1284.8 | 1369.75 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 110.941 | 1 | no | ((-642237.619354163,-1063079.06039345,230.694544012251),(-642180.3794898,-1063051.43689699,231.600790956065)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 11.82 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1419.38 | 1482.8 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 137.812 | 1 | no | ((-641292.76239552,-1063500.3118938,234.14),(-641279.909841893,-1063487.42529084,235.440000000005)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 4.03383 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2462.96 | 2477.03 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-horní podkladní vrstva | 137.391 | 1 | no | ((-641292.76239552,-1063500.3118938,234.09),(-641279.909841893,-1063487.42529084,235.380000000005)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklvaný materiál | TP210 | P2 | 128;128;128 | 3.36153 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2462.96 | 2477.03 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-spodní podkladní vrstva | 144.965 | 1 | no | ((-641292.76239552,-1063500.3118938,233.86),(-641279.909841893,-1063487.42529084,235.330000000005)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 15.463 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2462.96 | 2477.03 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
vozovka_chodník-obrusná vrstva | 1.84842 | 1 | no | ((-641292.656471243,-1063494.18712859,234.14),(-641283.963717633,-1063487.40778976,235.17)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0105614 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2462.95 | 2467.99 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-horní podkladní vrstva | 3.42182 | 1 | no | ((-641292.656471243,-1063494.18712859,234.09),(-641283.963717633,-1063487.36403706,235.11)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklvaný materiál | TP210 | P2 | 128;128;128 | 0.0540888 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2462.93 | 2467.99 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-spodní podkladní vrstva | 16.3105 | 1 | no | ((-641292.656471243,-1063494.18712859,233.86),(-641283.963717633,-1063487.10443768,235.06)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.00064 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2462.8 | 2467.99 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
vozovka_chodník-zpevnění krajnic | 13.5557 | 1 | no | ((-641292.656471243,-1063494.18712859,234.059680510368),(-641283.963717633,-1063487.13360615,235.17)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.517519 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2462.81 | 2467.99 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 1.84939 | 1 | no | ((-641281.920798436,-1063500.08544282,234.19000000001),(-641279.889898253,-1063489.12007927,235.440000000005)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.010561 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2471.99 | 2477.04 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-horní podkladní vrstva | 3.42565 | 1 | no | ((-641281.920798436,-1063500.08544282,234.14000000001),(-641279.840039152,-1063489.12007927,235.380000000005)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklvaný materiál | TP210 | P2 | 128;128;128 | 0.0540865 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2471.99 | 2477.06 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-spodní podkladní vrstva | 16.331 | 1 | no | ((-641281.920798436,-1063500.08544282,233.91000000001),(-641279.544208485,-1063489.12007927,235.330000000005)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.00059 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2471.99 | 2477.19 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
vozovka_chodník-zpevnění krajnic | 13.5744 | 1 | no | ((-641281.920798436,-1063500.08544282,234.109680510378),(-641279.577447886,-1063489.12007927,235.440000000005)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.517489 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 2471.99 | 2477.17 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 104.387 | 1 | no | ((-641292.582822189,-1063499.71192679,233.06),(-641277.119803328,-1063487.13360615,235.400000000005)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 6.18186 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2462.81 | 2477.17 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
propustky-obetonování | 32.6686 | 1 | no | ((-641288.837948807,-1063494.95172522,233.099999999972),(-641279.531748076,-1063489.81175458,233.700212901287)) | ByLayer | 8 | propustky-obetonování | Barva_8 | nerelevantni | D.1.1.4 | beton C20/25nXF3 | nerelevantni | P50 | 128;128;128 | 3.21611 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 2465 | 2475 | obetonování | 89952A | I1+S1+E1+Z1+M3+F1
propustky-podkladní vrstva | 33.2935 | 1 | no | ((-641288.921364605,-1063495.13349927,232.99999999999),(-641279.156942283,-1063489.49022643,233.260000000116)) | ByLayer | 2 | propustky-podkladní vrstva | Barva_2 | nerelevantni | D.1.1.4 | štěrkodrť fr. 0/32 | nerelevantni | P50 | 255;255;0 | 1.49355 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 2464.99 | 2475 | podkladní vrstva | 45152 | I1+S1+E1+Z1+M3+F1
propustky-zpevnění dlažbou | 19.1601 | 1 | no | ((-641289.825490071,-1063495.54143297,233.03),(-641278.252268798,-1063489.08254421,234.616422208362)) | ByLayer | 8 | propustky-zpevnění dlažbou | Barva_8 | nerelevantni | D.1.1.4 | lomový kámen, spárováno MC | nerelevantni | P50 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 2463.99 | 2476 | zpevnění dlažbou | 465512 | I1+S1+E1+Z1+M2+F1 | CZ_M2 - Způsob stanovení plochy: 3D plocha TIN povrchu; Plocha: 8.0839
propustky-lože | 17.2818 | 1 | no | ((-641289.825490071,-1063495.54143297,232.93),(-641278.252268798,-1063489.08254421,234.416422208362)) | ByLayer | 16 | propustky-lože | Barva_16 | nerelevantni | D.1.1.4 | beton | nerelevantni | P50 | 128;0;0 | 0.633486 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 2463.99 | 2476 | lože | 45131A | I1+S1;4+E1+Z1+M3+F1 | CZ_S4 - Specifikace: nerelevantni; Beton: C20/25nXF3; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.1.4; Návrhová životnost: 25
propustky-propust | 31.5083 | 1 | no | ((-641288.290868943,-1063494.43414784,233.25566416147),(-641279.775413477,-1063490.2175401,233.993727102438)) | ByLayer | 8 | propustky-propust | Barva_8 | nerelevantni | D.1.1.4 | PP | nerelevantni | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 2465.35 | 2474.66 | propust | 87458 | I1+S1;2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: nerelevantni; Stavební výrobek: nerelevantni; Specifikace: PP SN16 DN600; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 9.31
zemní práce-násyp | 145.4 | 1 | no | ((-641292.76239552,-1063500.3118938,233.031969696919),(-641279.909841893,-1063487.47507546,235.100000000005)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 48.9874 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2462.96 | 2477.03 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
propustky-zásypy a obsypy | 32.0452 | 1 | no | ((-641287.200070837,-1063494.5346389,233.982394701789),(-641281.189406064,-1063490.22035356,234.670433623357)) | ByLayer | 40 | propustky-zásypy a obsypy | Barva_40 | vhodná nebo podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P50 | 255;165;0 | 6.04185 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 2467.03 | 2472.94 | zásypy a obsypy | 17511 | I1+S1;3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
propustky-zásypy a obsypy | 63.2533 | 1 | no | ((-641289.011198292,-1063495.31627023,233),(-641279.118328244,-1063489.4084152,234.10024008734)) | ByLayer | 40 | propustky-zásypy a obsypy | Barva_40 | vhodná nebo podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P50 | 255;165;0 | 8.89055 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 2464.99 | 2475 | zásypy a obsypy | 17511 | I1+S1;3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
vozovka_chodník-obrusná vrstva | 119.404 | 1 | no | ((-640752.22986135,-1063770.07965099,237.36),(-640740.854028508,-1063756.16736261,238.02)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 3.50296 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3064.67 | 3075.33 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-horní podkladní vrstva | 118.987 | 1 | no | ((-640752.22986135,-1063770.07965099,237.31),(-640740.854028508,-1063756.16736261,237.96)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklvaný materiál | TP210 | P2 | 128;128;128 | 2.91914 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3064.67 | 3075.33 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-spodní podkladní vrstva | 126.487 | 1 | no | ((-640752.22986135,-1063770.07965099,237.08),(-640740.854028508,-1063756.16736261,237.91)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 13.428 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3064.67 | 3075.33 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
vozovka_chodník-obrusná vrstva | 2.0774 | 1 | no | ((-640748.530524109,-1063770.0910621,237.36),(-640740.947582434,-1063760.46799395,237.96)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0118839 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3071.96 | 3075.34 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-horní podkladní vrstva | 3.83976 | 1 | no | ((-640748.530524109,-1063770.11958986,237.31),(-640740.947582434,-1063760.46799395,237.9)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklvaný materiál | TP210 | P2 | 128;128;128 | 0.0608616 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3071.96 | 3075.36 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-spodní podkladní vrstva | 18.2807 | 1 | no | ((-640748.530524109,-1063770.28885461,237.08),(-640740.947582434,-1063760.46799395,237.85)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.1259 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3071.96 | 3075.51 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
vozovka_chodník-zpevnění krajnic | 15.1953 | 1 | no | ((-640748.530524109,-1063770.2698361,237.279680510368),(-640740.947582434,-1063760.46799395,237.96)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.582291 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3071.96 | 3075.49 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 2.07746 | 1 | no | ((-640752.257606379,-1063768.55817014,237.44),(-640749.180985918,-1063756.39796685,238.02)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D.1.1.4 | ACO 16 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0118843 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3064.66 | 3068.04 | obrusná vrstva | 574A05 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-horní podkladní vrstva | 3.83978 | 1 | no | ((-640752.326968952,-1063768.55817014,237.39),(-640749.180985918,-1063756.39796685,237.96)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | Recyklvaný materiál | TP210 | P2 | 128;128;128 | 0.0608635 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3064.63 | 3068.04 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-spodní podkladní vrstva | 18.2807 | 1 | no | ((-640752.738520221,-1063768.55817014,237.16),(-640749.180985918,-1063756.39796685,237.91)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D.1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.12593 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3064.49 | 3068.04 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.23
vozovka_chodník-zpevnění krajnic | 15.1951 | 1 | no | ((-640752.692278505,-1063768.55817014,237.359680510368),(-640749.180985918,-1063756.39796685,238.02)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D.1.1.4 | Recyklovaný materiál | VL1 | P2 | 128;128;128 | 0.582306 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 3064.51 | 3068.04 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 137.987 | 1 | no | ((-640754.388101947,-1063770.42684662,235.351182820784),(-640740.63322944,-1063756.57116832,237.98)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D.1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 8.56761 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3063.93 | 3075.87 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
propustky-propust | 35.7458 | 1 | no | ((-640753.007169724,-1063767.97437859,235.370016250882),(-640743.285377822,-1063761.1933575,236.223836018266)) | ByLayer | 8 | propustky-propust | Barva_8 | nerelevantni | D.1.1.4 | PP | nerelevantni | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 3064.94 | 3075.57 | propust | 87458 | I1+S1;2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: nerelevantni; Stavební výrobek: nerelevantni; Specifikace: PP SN16 DN600; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10.63
propustky-podkladní vrstva | 36.3966 | 1 | no | ((-640753.11415296,-1063768.27687857,235.260031961648),(-640742.954240816,-1063761.02437648,235.800000000086)) | ByLayer | 2 | propustky-podkladní vrstva | Barva_2 | nerelevantni | D.1.1.4 | štěrkodrť fr. 0/32 | nerelevantni | P50 | 255;255;0 | 1.6387 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 3064.9 | 3075.87 | podkladní vrstva | 45152 | I1+S1+E1+Z1+M3+F1
propustky-zásypy a obsypy | 68.7409 | 2 | yes | ((-640753.253119366,-1063768.3054958,235.260031961651),(-640742.943782759,-1063760.88516803,236.645790617861)) | ByLayer | 40 | propustky-zásypy a obsypy | Barva_40 | vhodná nebo podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P50 | 255;165;0 | 9.71413 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 3064.86 | 3075.87 | zásypy a obsypy | 17511 | I1+S1;3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
propustky-zpevnění dlažbou | 18.0817 | 1 | no | ((-640753.953254215,-1063768.80372051,235.28),(-640742.114043037,-1063760.49828449,236.925869228065)) | ByLayer | 8 | propustky-zpevnění dlažbou | Barva_8 | nerelevantni | D.1.1.4 | lomový kámen, spárováno MC | nerelevantni | P50 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 3063.93 | 3076.83 | zpevnění dlažbou | 465512 | I1+S1+E1+Z1+M2+F1 | CZ_M2 - Způsob stanovení plochy: 3D plocha TIN povrchu; Plocha: 7.54736
propustky-lože | 16.0245 | 1 | no | ((-640753.953254215,-1063768.80372051,235.18),(-640742.114043037,-1063760.49828449,236.725869228065)) | ByLayer | 16 | propustky-lože | Barva_16 | nerelevantni | D.1.1.4 | beton | nerelevantni | P50 | 128;0;0 | 0.612702 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 3063.93 | 3076.83 | lože | 45131A | I1+S1;4+E1+Z1+M3+F1 | CZ_S4 - Specifikace: nerelevantni; Beton: C20/25nXF3; Typ betonářské vyztuže: nerelevantni; Množství betonářské výztuže na m3: 0; Množství betonářské výztuže: 0; Typ předpínací vyztuže: nerelevantni; Množství předpínací výztuže: 0; Referencované výkresy: D.1.1.4; Návrhová životnost: 25
propustky-propust | 36.8789 | 1 | no | ((-640752.743350233,-1063767.6933134,235.510031961651),(-640743.359810251,-1063761.58105595,236.516429711103)) | ByLayer | 8 | propustky-propust | Barva_8 | nerelevantni | D.1.1.4 | PP | nerelevantni | P10 | 128;128;128 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 3065.04 | 3075.72 | propust | 87458 | I1+S1;2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: nerelevantni; Stavební výrobek: nerelevantni; Specifikace: PP SN16 DN600; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 10.68
propustky-zásypy a obsypy | 26.4716 | 1 | no | ((-640753.177690857,-1063767.77626317,236.265473422292),(-640744.100016237,-1063761.25199061,237.634434769459)) | ByLayer | 40 | propustky-zásypy a obsypy | Barva_40 | vhodná nebo podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P50 | 255;165;0 | 4.26401 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 3064.96 | 3074.43 | zásypy a obsypy | 17511 | I1+S1;3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-násyp | 143.459 | 1 | no | ((-640752.22986135,-1063770.07965099,235.934411909901),(-640740.854028508,-1063756.16736261,237.68)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 47.9206 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3064.67 | 3075.33 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
propustky-zásypy a obsypy | 29.4133 | 1 | no | ((-640750.510902127,-1063766.55123252,236.357078851182),(-640746.233477966,-1063762.3220502,237.480255322651)) | ByLayer | 40 | propustky-zásypy a obsypy | Barva_40 | vhodná nebo podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P50 | 255;165;0 | 8.21096 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | propustky | 3068.02 | 3071.97 | zásypy a obsypy | 17511 | I1+S1;3+E1+Z1+M3+F1 | CZ_S3 - Klasifikace zemin / hornin: nerelevantni; Třída těžitelnosti: 1; Další specifikace: nerelevantni
zemní práce-násyp | 41.4555 | 2 | yes | ((-640753.775717208,-1063770.41148491,236.183492990712),(-640744.641101169,-1063762.91953821,237.528816602924)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 5.94471 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3064.64 | 3075.55 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 74.0528 | 2 | yes | ((-640752.683050209,-1063765.91699697,235.923459495345),(-640740.63322944,-1063756.57116832,237.83)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 18.3805 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 3063.93 | 3075.87 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 53.1717 | 2 | yes | ((-641292.582822189,-1063499.71192679,233.03),(-641278.346722861,-1063491.36692518,235.250000000005)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 9.49041 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2462.81 | 2477.17 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
zemní práce-násyp | 13.845 | 2 | yes | ((-641287.504980691,-1063494.25373223,233.281977973659),(-641277.119803328,-1063487.13360615,234.631090886623)) | ByLayer | 3 | zemní práce-násyp | Barva_3 | vhodná, podmínečně vhodná | D.1.1.4 | zemina | ČSN 73 6133 | P100 | 0;255;0 | 0.816356 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 2464.97 | 2477.03 | násyp | 17111 | I1+S1+E1+Z1+M3+F1
odvodnění-trativod | 176.116 | 1 | no | ((-641213.641980199,-1063650.12375817,235.752346192821),(-640958.120532266,-1063530.46001306,238.582746980379)) | ByLayer | 40 | odvodnění-trativod | Barva_40 |  |  |  |  | P100 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | odvodnění | 2550 | 2832 | trativod | 21264 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: trativod; Stavební výrobek: nerelevantni; Specifikace: plast DN200, částečná perforace; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 282
