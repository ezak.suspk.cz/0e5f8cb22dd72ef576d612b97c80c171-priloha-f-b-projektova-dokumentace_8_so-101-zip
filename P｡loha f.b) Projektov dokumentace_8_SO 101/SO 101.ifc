Properties of the parts of a building model (IFC4X3_ADD2), part 14 of 21

# IfcBuiltElement (2093)
Name | Area | NumChanges | RecordHistory = ShowHistory | Bounds | Linetype | ColorIndex | Layer | PlotStyleName | podrobná specifikace | CZ_S1, Reference | Materiál | specifikace | Skupina přesnosti | Textura / barva | Objem | Způsob stanovení objemu | Označení stavebního objektu | Označení podobjektu = Označení části objektu | CZ_I1, Fáze projektu | Název stavebního objektu | CZ_I1, Klasifikační systém | Skupina elementů | CZ_I1, Staničení od | CZ_I1, Staničení do | CZ_I1, Označení elementu | CZ_I1, Označení položky | CZ_I1, Označení šablony vlastností | Tloušťka
vozovka_chodník-podkladní asfaltová vrstva | 69.6307 | 1 | no | ((-642989.841857155,-1062730.08172635,232.450438294134),(-642859.21302735,-1062670.96684772,232.698662379268)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.68736 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 209.076 | 1 | no | ((-642990.013669004,-1062730.46233506,232.240146086342),(-642859.21302735,-1062670.96684772,232.628662379268)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 12.6554 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 383.951 | 1 | no | ((-642990.235495677,-1062730.98518128,231.949958269521),(-642859.21302735,-1062670.96684772,232.428662379268)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 37.9546 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 395.377 | 1 | no | ((-642990.285869659,-1062731.06533154,232.37461095842),(-642859.21302735,-1062670.96684772,232.798662379268)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 24.8374 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 15.0763 | 1 | no | ((-642986.216601556,-1062718.04728268,232.584599082547),(-642854.314550187,-1062663.22349044,232.906939171709)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0578554 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 42.6981 | 1 | no | ((-642986.216601556,-1062718.04728268,232.522589588876),(-642854.283912229,-1062663.15044512,232.866939171709)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.732233 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 69.448 | 1 | no | ((-642986.216601556,-1062718.04728268,232.450453512926),(-642854.251344321,-1062663.07279851,232.806939171709)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.68321 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 208.514 | 1 | no | ((-642986.216601556,-1062718.04728268,232.240161305134),(-642854.094423084,-1062662.6986756,232.736939171709)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 12.6233 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 721.389 | 1 | no | ((-642986.216601556,-1062718.04728268,231.913416375383),(-642853.427306461,-1062661.10817313,232.536939171709)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 60.8845 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 1188.96 | 1 | no | ((-642985.607715947,-1062716.69843992,231.552711794639),(-642852.540411755,-1062659.28639215,233.088264294713)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 82.9964 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 565 | 708 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 553.02 | 1 | no | ((-642986.216601556,-1062718.04728268,232.325963465889),(-642853.61395693,-1062661.55317483,232.906939171709)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 33.9881 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 565 | 708 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 553.996 | 1 | no | ((-642986.140964142,-1062717.87972579,232.073062635829),(-642853.549009643,-1062661.39833111,232.741960802492)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 47.2785 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 565 | 708 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 466.102 | 1 | no | ((-642855.942221873,-1062735.51841293,232.866939171709),(-642811.160233609,-1062718.04728268,233.238188948216)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 9.23818 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 708 | 753.5 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 470.57 | 1 | no | ((-642857.5879806,-1062741.08899148,232.865246543118),(-642812.565330045,-1062721.97643728,233.238188948216)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 9.32679 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 708 | 753.5 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 468.123 | 1 | no | ((-642855.942221873,-1062735.51841293,232.806939171709),(-642811.160233609,-1062718.04728268,233.198188948216)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 13.8573 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 708 | 753.5 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 472.609 | 1 | no | ((-642857.5879806,-1062741.08899148,232.805246543118),(-642812.565330045,-1062721.97643728,233.198188948216)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 13.9902 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 708 | 753.5 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 469.134 | 1 | no | ((-642855.942221873,-1062735.51841293,232.736939171709),(-642811.160233609,-1062718.04728268,233.138188948216)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 16.1668 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 708 | 753.5 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 473.629 | 1 | no | ((-642857.5879806,-1062741.08899148,232.735246543118),(-642812.565330045,-1062721.97643728,233.138188948216)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 16.3219 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 708 | 753.5 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 482.273 | 1 | no | ((-642855.942221873,-1062735.51841293,232.536939171709),(-642811.160233609,-1062718.04728268,233.068188948216)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 46.1909 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 708 | 753.5 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 486.886 | 1 | no | ((-642857.5879806,-1062741.08899148,232.535246543118),(-642812.565330045,-1062721.97643728,233.068188948216)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 46.6339 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 708 | 753.5 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 488.659 | 1 | no | ((-642855.942221873,-1062735.51841293,232.265689171708),(-642811.160233609,-1062718.04728268,232.868188948216)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 60.7451 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 708 | 753.5 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 493.324 | 1 | no | ((-642857.5879806,-1062741.08899148,232.2636580174),(-642812.565330045,-1062721.97643728,232.868188948216)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 61.2914 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 708 | 753.5 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 4.71286 | 1 | no | ((-642854.322269988,-1062729.01638596,232.866432842595),(-642811.155955625,-1062718.02855849,233.071886041777)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0180591 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 708 | 753.5 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 13.3428 | 1 | no | ((-642854.322269988,-1062729.01638596,232.804423348924),(-642811.138977374,-1062717.95424685,233.031886041777)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.228534 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 708 | 753.5 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 21.6989 | 1 | no | ((-642854.322269988,-1062729.01638596,232.732287272975),(-642811.120929628,-1062717.87525417,232.971886041777)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.525258 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 708 | 753.5 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 65.1736 | 1 | no | ((-642854.322269988,-1062729.01638596,232.521995065182),(-642811.033970567,-1062717.49464546,232.901886041777)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 3.93705 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 708 | 753.5 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 225.132 | 1 | no | ((-642854.322269988,-1062729.01638596,232.19525013543),(-642810.742517736,-1062715.87657002,232.701886041777)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 19.1125 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 708 | 753.5 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 309.885 | 1 | no | ((-642853.766155356,-1062728.3171386,231.834545554687),(-642810.319998962,-1062713.7254281,232.86417573477)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 21.2686 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 708 | 753.5 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 171.041 | 1 | no | ((-642854.322269988,-1062729.01638596,232.607797225938),(-642810.902486225,-1062716.32928628,233.071886041777)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 10.473 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 708 | 753.5 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 172.554 | 1 | no | ((-642854.253187927,-1062728.83923601,232.354896395876),(-642810.828188213,-1062716.17175818,232.90690767256)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 14.7552 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 708 | 753.5 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 34.1622 | 1 | no | ((-642742.645783995,-1062732.63893628,233.002353221903),(-642737.206999862,-1062728.67360947,233.20438565569)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.669586 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 800.54 | 815.84 | obrusná vrstva | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 39.7544 | 1 | no | ((-642742.169770075,-1062736.64033753,232.990435885526),(-642736.676966807,-1062731.93421011,233.20438565569)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.780469 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 803.65 | 818.88 | obrusná vrstva | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 34.6634 | 1 | no | ((-642742.645783995,-1062732.63893628,232.932353221903),(-642737.206999862,-1062728.67360947,233.16438565569)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.17178 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 800.54 | 815.84 | ložní vrstva | 574FE06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-ložní vrstva | 40.2897 | 1 | no | ((-642742.169770075,-1062736.64033753,232.920435885526),(-642736.676966807,-1062731.93421011,233.16438565569)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.36582 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 803.65 | 818.88 | ložní vrstva | 574FE06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 35.9998 | 1 | no | ((-642742.645783995,-1062732.63893628,232.782353221903),(-642737.206999862,-1062728.67360947,233.09438565569)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 2.51095 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 800.54 | 815.84 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-horní podkladní vrstva | 41.7172 | 1 | no | ((-642742.169770075,-1062736.64033753,232.770435885526),(-642736.676966807,-1062731.93421011,233.09438565569)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 2.92676 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 803.65 | 818.88 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 36.9768 | 1 | no | ((-642742.645783995,-1062732.63893628,232.56588666624),(-642737.206999862,-1062728.67360947,232.94438565569)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 3.4877 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 800.54 | 815.84 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 42.7862 | 1 | no | ((-642742.169770075,-1062736.64033753,232.551585862588),(-642736.676966807,-1062731.93421011,232.94438565569)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 4.0923 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 803.65 | 818.88 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
zemní práce-rozprostření ornice (ohumusovani) | 18.6185 | 1 | no | ((-642741.501882908,-1062738.88237842,232.039955601983),(-642736.357042284,-1062736.3687136,232.89614895099)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 1.14759 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 816.38 | 820.7 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 0.530537 | 1 | no | ((-642741.601560781,-1062736.66038953,232.989929556412),(-642736.674119371,-1062735.6667695,233.103347068505)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0020304 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 815.82 | 818.89 | obrusná vrstva | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 1.64394 | 1 | no | ((-642741.601560781,-1062736.74498391,232.917793480463),(-642736.66210675,-1062735.6667695,233.063347068505)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0308685 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 815.82 | 818.96 | ložní vrstva | 574FE06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 5.49467 | 1 | no | ((-642741.601560781,-1062737.07543504,232.759449324619),(-642736.615181837,-1062735.6667695,232.993347068505)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.242542 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 815.82 | 819.23 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 15.2189 | 1 | no | ((-642741.601560781,-1062737.96218861,232.511619165273),(-642736.489666675,-1062735.6667695,232.843347068505)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.09478 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 815.82 | 819.95 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-zpevnění krajnic | 12.0296 | 1 | no | ((-642741.601560781,-1062737.7376135,232.791293939767),(-642736.52115079,-1062735.6667695,233.103347068505)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 0.608911 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 815.82 | 819.77 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 7.78859 | 1 | no | ((-642741.560229653,-1062737.64606743,232.671265425719),(-642736.534556697,-1062735.95782849,232.929349520735)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.287334 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 816.05 | 819.69 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
zemní práce-rozprostření ornice (ohumusovani) | 26.7778 | 1 | no | ((-642743.187271291,-1062727.84229164,232.000002238423),(-642737.875135545,-1062725.09722232,232.852543069335)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 1.74211 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 797 | 801.26 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 0.529979 | 1 | no | ((-642742.648631431,-1062729.28678644,233.001846892789),(-642737.670013559,-1062728.65355747,233.119741186855)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0020304 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 800.52 | 802.6 | obrusná vrstva | 574A03 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 1.64297 | 1 | no | ((-642742.660644052,-1062729.28678644,232.92971081684),(-642737.670013559,-1062728.56896309,233.079741186855)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0308685 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 800.44 | 802.6 | ložní vrstva | 574FE06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 5.49276 | 1 | no | ((-642742.707568965,-1062729.28678644,232.771366660995),(-642737.670013559,-1062728.23851195,233.009741186855)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 0.242542 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 800.13 | 802.6 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 22.0574 | 1 | no | ((-642742.92673611,-1062729.28678644,232.505965722153),(-642737.670013559,-1062726.6960833,232.859741186855)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.58548 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 798.7 | 802.6 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-zpevnění krajnic | 19.797 | 1 | no | ((-642742.907044126,-1062729.28678644,232.743211276146),(-642737.670013559,-1062726.8337828,233.119741186855)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 1.17463 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 798.83 | 802.6 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 14.5674 | 1 | no | ((-642742.881846088,-1062728.99572744,232.665611982598),(-642737.711344688,-1062727.01220448,232.945743639081)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 0.692028 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 799 | 802.33 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 161.01 | 1 | no | ((-642801.451435051,-1062717.74553563,233.142873978557),(-642781.662730037,-1062708.1749905,233.379999999888)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 3.18139 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 760.07 | 786.43 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 161.482 | 1 | no | ((-642801.451435051,-1062717.74553563,233.092873978557),(-642781.662730037,-1062708.1749905,233.339999999888)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 3.97673 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 760.07 | 786.43 | ložní vrstva | 574C06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-podkladní asfaltová vrstva | 161.954 | 1 | no | ((-642801.451435051,-1062717.74553563,233.032873978557),(-642781.662730037,-1062708.1749905,233.289999999888)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 5.72652 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 760.07 | 786.43 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-horní podkladní vrstva | 166.204 | 1 | no | ((-642801.451435051,-1062717.74553563,232.882873978557),(-642781.662730037,-1062708.1749905,233.229999999888)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 11.9302 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 760.07 | 786.43 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 169.062 | 1 | no | ((-642801.451435051,-1062717.74553563,232.662873978557),(-642781.662730037,-1062708.1749905,233.079999999888)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 16.72 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 760.07 | 786.43 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-obrusná vrstva | 2.08374 | 1 | no | ((-642800.569795811,-1062713.79441156,233.142367649444),(-642781.656247559,-1062708.15523541,233.275736942235)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00799279 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 760.23 | 786.43 | obrusná vrstva | 574A04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 5.38627 | 1 | no | ((-642800.569795811,-1062713.79441156,233.090484738051),(-642781.632140845,-1062708.08177119,233.235736942235)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0818126 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 760.23 | 786.46 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.05
vozovka_chodník-podkladní asfaltová vrstva | 8.89365 | 1 | no | ((-642800.569795811,-1062713.79441156,233.02847524438),(-642781.606413511,-1062708.00336819,233.185736942235)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16+ 50/70 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.22848 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 760.23 | 786.49 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-horní podkladní vrstva | 24.1576 | 1 | no | ((-642800.569795811,-1062713.79441156,232.870131088536),(-642781.49958417,-1062707.67781015,233.125736942235)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 1.16386 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 760.23 | 786.62 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-spodní podkladní vrstva | 70.1108 | 1 | no | ((-642800.569795811,-1062713.79441156,232.614351406467),(-642781.144301363,-1062706.59734803,232.975736942235)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 5.15626 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 760.23 | 787.05 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
zemní práce-rozprostření ornice (ohumusovani) | 141.428 | 1 | no | ((-642800.412117188,-1062713.11665751,232.164270939623),(-642780.360572567,-1062704.5791939,233.068026635229)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 9.52832 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 760.26 | 788.01 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-zpevnění krajnic | 51.3566 | 1 | no | ((-642800.569795811,-1062713.79441156,232.934774935498),(-642781.272162525,-1062706.984752,233.275736942235)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 2.6043 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 760.23 | 786.9 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 38.3106 | 1 | no | ((-642800.503091758,-1062713.50769583,232.77658652519),(-642781.2741188,-1062706.99296136,233.101046788015)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 1.69804 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 760.24 | 786.9 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrubník | 156.38 | 1 | no | ((-642819.151414158,-1062773.12244098,232.850000000003),(-642759.453526424,-1062740.3856461,233.56)) | ByLayer | 40 | vozovka_chodník-obrubník | Barva_40 |  |  |  |  | P2 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 748.42 | 827.02 | obrubník | 91726 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obruba; Stavební výrobek: obrubník KO; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 138.63
vozovka_chodník-obrubník | 182.431 | 1 | no | ((-642819.151414158,-1062773.12244098,232.750000000003),(-642759.453526424,-1062740.3856461,233.41)) | ByLayer | 40 | vozovka_chodník-obrubník | Barva_40 |  |  |  |  | P2 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0.74842 | 0.82702 | obrubník | nerelevantni | nerelevantni | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obruba; Stavební výrobek: lože; Specifikace: C20/25nXF3; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 0
vozovka_chodník-spodní podkladní vrstva | 192.27 | 1 | no | ((-642819.151414158,-1062773.12244098,232.500000000003),(-642759.453526424,-1062740.3856461,233.16)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 15.43 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 748.42 | 827.02 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrubník | 73.3098 | 1 | no | ((-642770.758583454,-1062774.31188188,233.262829252988),(-642746.598541893,-1062753.02926643,233.743635866844)) | ByLayer | 40 | vozovka_chodník-obrubník | Barva_40 |  |  |  |  | P2 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 809.05 | 836.92 | obrubník | 91726 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obruba; Stavební výrobek: obrubník KO; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 65.46
vozovka_chodník-obrubník | 85.1035 | 1 | no | ((-642770.758583454,-1062774.31188188,233.162829252988),(-642746.598541893,-1062753.02926643,233.593635866844)) | ByLayer | 40 | vozovka_chodník-obrubník | Barva_40 |  |  |  |  | P2 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0.80912 | 0.83692 | obrubník | nerelevantni | nerelevantni | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obruba; Stavební výrobek: lože; Specifikace: C20/25nXF3; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 0
vozovka_chodník-spodní podkladní vrstva | 89.8419 | 1 | no | ((-642770.758583454,-1062774.31188188,232.912829252988),(-642746.598541893,-1062753.02926643,233.343635866844)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 7.19965 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 809.12 | 836.92 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrubník | 12.969 | 1 | no | ((-642757.486115636,-1062736.89871173,233.199081802812),(-642753.087608161,-1062733.85527339,233.589649724311)) | ByLayer | 40 | vozovka_chodník-obrubník | Barva_40 |  |  |  |  | P2 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 796.93 | 799.91 | obrubník | 91726 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obruba; Stavební výrobek: obrubník KO; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 12.34
vozovka_chodník-obrubník | 14.4164 | 1 | no | ((-642757.486115636,-1062736.89871173,233.099081802812),(-642753.087608161,-1062733.85527339,233.439649724311)) | ByLayer | 40 | vozovka_chodník-obrubník | Barva_40 |  |  |  |  | P2 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0.79693 | 0.79991 | obrubník | nerelevantni | nerelevantni | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obruba; Stavební výrobek: lože; Specifikace: C20/25nXF3; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 0
vozovka_chodník-spodní podkladní vrstva | 15.4494 | 1 | no | ((-642757.486115636,-1062736.89871173,232.849081802812),(-642753.087608161,-1062733.85527339,233.189649724311)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDB | ČSN 73 6126-1 | P2 | 128;128;128 | 1.22087 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 796.93 | 799.91 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-obrubník | 29.0892 | 1 | no | ((-642807.809974935,-1062739.73684045,233.051052345314),(-642797.287151205,-1062735.24527981,233.444960504581)) | ByLayer | 40 | vozovka_chodník-obrubník | Barva_40 |  |  |  |  | P2 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 758.38 | 769.02 | obrubník | 91726 | I1+S2+E1+Z1+M1+F1 | CZ_S2 - Reference: D1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obruba; Stavební výrobek: obrubník KO; Specifikace: nerelevantni; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 26.52
vozovka_chodník-obrubník | 33.2929 | 1 | no | ((-642807.809974935,-1062739.73684045,232.951052345314),(-642797.287151205,-1062735.24527981,233.294960504581)) | ByLayer | 40 | vozovka_chodník-obrubník | Barva_40 |  |  |  |  | P2 | 255;165;0 |  |  | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 0.75838 | 0.76902 | obrubník | nerelevantni | nerelevantni | CZ_S2 - Reference: D.1.1.4; Výrobce: nerelevantni; Kategorie stavebního výrobku: nerelevantni; Typ stavebního výrobku: obruba; Stavební výrobek: lože; Specifikace: C20/25nXF3; Podrobná specifikace: nerelevantni; CZ_M1 - Způsob stanovení délky: Délka 3D křivky; Délka: 0
vozovka_chodník-spodní podkladní vrstva | 35.3159 | 1 | no | ((-642807.809974935,-1062739.73684045,232.701052345314),(-642797.287151205,-1062735.24527981,233.044960504581)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 2.81805 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 758.38 | 769.02 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 839.42 | 2 | yes | ((-642760.058795207,-1062812.97961681,233.326673054075),(-642695.149570752,-1062753.73181304,233.760653447312)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 16.642 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 816.7 | 900 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 852.352 | 2 | yes | ((-642767.029850715,-1062816.34690847,233.305364311834),(-642697.742586851,-1062762.34776746,233.760653447312)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 16.8991 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 816.7 | 900 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 842.948 | 2 | yes | ((-642760.058795207,-1062812.97961681,233.266673054075),(-642695.149570752,-1062753.73181304,233.720653447312)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 24.9629 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 816.7 | 900 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 855.92 | 2 | yes | ((-642767.029850715,-1062816.34690847,233.245364311834),(-642697.742586851,-1062762.34776746,233.720653447312)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 25.3486 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 816.7 | 900 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 844.712 | 2 | yes | ((-642760.058795207,-1062812.97961681,233.196673054075),(-642695.149570752,-1062753.73181304,233.660653447312)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 29.1234 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 816.7 | 900 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 857.704 | 2 | yes | ((-642767.029850715,-1062816.34690847,233.175364311834),(-642697.742586851,-1062762.34776746,233.660653447312)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 29.5733 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 816.7 | 900 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 867.646 | 2 | yes | ((-642760.058795207,-1062812.97961681,232.996673054075),(-642695.149570752,-1062753.73181304,233.590653447312)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 83.2098 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 816.7 | 900 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 880.896 | 2 | yes | ((-642767.029850715,-1062816.34690847,232.975364311834),(-642697.742586851,-1062762.34776746,233.590653447312)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 84.4949 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 816.7 | 900 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 879.051 | 2 | yes | ((-642760.058795207,-1062812.97961681,232.709156198952),(-642695.149570752,-1062753.73181304,233.390653447312)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 109.964 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 816.7 | 900 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 892.908 | 2 | yes | ((-642767.029850715,-1062816.34690847,232.683585708263),(-642697.742586851,-1062762.34776746,233.390653447312)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 112.692 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 816.7 | 900 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 827.857 | 1 | no | ((-642755.771396537,-1062808.46409113,230.279137936072),(-642689.586076388,-1062751.55858411,233.498926011644)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 62.1 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 0.8167 | 0.9 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
vozovka_chodník-obrusná vrstva | 8.75307 | 1 | no | ((-642756.257334408,-1062809.61230816,233.326166724961),(-642695.137213862,-1062753.71694937,233.654403447312)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0335429 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 816.7 | 900 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 24.7778 | 1 | no | ((-642756.257334408,-1062809.61230816,233.26415723129),(-642695.088172456,-1062753.65795919,233.614403447312)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.424566 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 816.7 | 900 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 40.2947 | 1 | no | ((-642756.257334408,-1062809.61230816,233.192021155341),(-642695.036041827,-1062753.59525309,233.554403447312)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.975922 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 816.7 | 900 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 120.996 | 1 | no | ((-642756.257334408,-1062809.61230816,232.981728947549),(-642694.784861963,-1062753.29311765,233.484403447312)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 7.31803 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 816.7 | 900 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 458.558 | 1 | no | ((-642756.257334408,-1062809.61230816,232.649483611581),(-642693.619243567,-1062752.27203528,233.284403447312)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 38.1617 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 816.7 | 900 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-zpevnění krajnic | 333.527 | 1 | no | ((-642756.257334408,-1062809.61230816,233.093293586977),(-642694.077902139,-1062752.83628108,233.654403447312)) | ByLayer | 8 | vozovka_chodník-zpevnění krajnic | Barva_8 | nerelevantni | D1.1.4 | Recyklovaný materiál | VL 1 | P2 | 128;128;128 | 20.1043 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 816.7 | 900 | zpevnění krajnic | 56960 | I1+S1+E1+Z1+M3+F1
zemní práce-zemní krajnice a dosypávky | 346.044 | 1 | no | ((-642756.134225083,-1062809.46871092,232.811718730305),(-642693.866701376,-1062752.56969359,233.489425078093)) | ByLayer | 8 | zemní práce-zemní krajnice a dosypávky | Barva_8 | nerelevantni | D1.1.4 | nenamrzavý materiál | VL 1 | P100 | 128;128;128 | 29.3652 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 816.7 | 900 | zemní krajnice a dosypávky | 173103 | I1+S1+E1+Z1+M3+F1
vozovka_chodník-obrusná vrstva | 52.3406 | 1 | no | ((-642681.794298284,-1062828.56969645,233.521188629689),(-642674.394116097,-1062821.56442023,233.691950739076)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.02999 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 95.6628 | 1 | no | ((-642686.388392409,-1062834.84141227,233.433688629821),(-642676.890806035,-1062824.98719869,233.691950739062)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.89049 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 52.753 | 1 | no | ((-642681.794298284,-1062828.56969645,233.461188629689),(-642674.394116097,-1062821.56442023,233.651950739076)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.54498 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 96.2167 | 1 | no | ((-642686.388392409,-1062834.84141227,233.373688629821),(-642676.890806035,-1062824.98719869,233.651950739062)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 2.83574 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 52.9592 | 1 | no | ((-642681.794298284,-1062828.56969645,233.391188629689),(-642674.394116097,-1062821.56442023,233.591950739076)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 1.80248 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 96.4937 | 1 | no | ((-642686.388392409,-1062834.84141227,233.303688629821),(-642676.890806035,-1062824.98719869,233.591950739062)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 3.30836 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 55.6394 | 1 | no | ((-642681.794298284,-1062828.56969645,233.191188629689),(-642674.394116097,-1062821.56442023,233.521950739076)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 5.14994 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 100.094 | 1 | no | ((-642686.388392409,-1062834.84141227,233.103688629821),(-642676.890806034,-1062824.98719869,233.521950739062)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 9.45246 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 56.8926 | 1 | no | ((-642681.794298284,-1062828.56969645,232.91993862969),(-642674.394116097,-1062821.56442023,233.321950739076)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 6.71081 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 102.023 | 1 | no | ((-642686.388392409,-1062834.84141227,232.814938629822),(-642676.890806035,-1062824.98719869,233.321950739062)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 12.7326 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 919.96 | 926.04 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-obrusná vrstva | 1.66616 | 1 | no | ((-642594.439367672,-1062894.61936729,232.938846696014),(-642580.564207408,-1062887.07385658,233.053215299586)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00639101 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1026.85 | 1042.55 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-obrusná vrstva | 2.22576 | 1 | no | ((-642548.149184274,-1062920.78213846,232.650722497217),(-642529.184212038,-1062911.54259834,232.796698659271)) | ByLayer | 8 | vozovka_chodník-obrusná vrstva | Barva_8 | nerelevantni | D1.1.4 | ACO 11+ PMB 45/80-55 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.00854046 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1078.97 | 1100 | obrusná vrstva | 574B04 | I1+S1+E1+Z1+M3;2&6+F1 | 0.04
vozovka_chodník-ložní vrstva | 4.72563 | 1 | no | ((-642594.479190242,-1062894.68985842,232.876837202343),(-642580.564207408,-1062887.07385658,233.013215299586)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.0808718 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1026.85 | 1042.55 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-ložní vrstva | 6.31065 | 1 | no | ((-642548.184989618,-1062920.85453329,232.588713003547),(-642529.184212038,-1062911.54259834,232.756698659271)) | ByLayer | 8 | vozovka_chodník-ložní vrstva | Barva_8 | nerelevantni | D1.1.4 | ACL 16S PMB 45/80-65 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.108069 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1078.97 | 1100 | ložní vrstva | 574D06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.06
vozovka_chodník-podkladní asfaltová vrstva | 7.6925 | 1 | no | ((-642594.52152132,-1062894.76478993,232.804701126394),(-642580.564207408,-1062887.07385658,232.953215299586)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.185916 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1026.85 | 1042.55 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-podkladní asfaltová vrstva | 10.2705 | 1 | no | ((-642548.223050416,-1062920.93148844,232.516576927597),(-642529.184212038,-1062911.54259834,232.696698659271)) | ByLayer | 8 | vozovka_chodník-podkladní asfaltová vrstva | Barva_8 | nerelevantni | D1.1.4 | ACP 16S PMB 25/55-60 | ČSN EN 13 108-1 | P2 | 128;128;128 | 0.248435 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1078.97 | 1100 | podkladní asfaltová vrstva | 574F06 | I1+S1+E1+Z1+M3;2&6+F1 | 0.07
vozovka_chodník-horní podkladní vrstva | 23.1958 | 1 | no | ((-642594.725484223,-1062895.12583079,232.594408918602),(-642580.564207408,-1062887.07385658,232.883215299586)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 1.39456 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1026.85 | 1042.55 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-horní podkladní vrstva | 30.9315 | 1 | no | ((-642548.406437925,-1062921.30227971,232.306284719805),(-642529.184212038,-1062911.54259834,232.626698659271)) | ByLayer | 8 | vozovka_chodník-horní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | MZK | ČSN 73 6126-1 | P2 | 128;128;128 | 1.86338 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1078.97 | 1100 | horní podkladní vrstva | 56310 | I1+S1+E1+Z1+M3;2&6+F1 | 0.2
vozovka_chodník-spodní podkladní vrstva | 67.586 | 1 | no | ((-642595.394315885,-1062896.30743129,232.279749371956),(-642580.564207408,-1062887.07385658,232.683215299586)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 5.67723 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1026.85 | 1042.55 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
vozovka_chodník-spodní podkladní vrstva | 90.0122 | 1 | no | ((-642549.006621439,-1062922.51579097,231.991625173159),(-642529.184212038,-1062911.54259834,232.426698659271)) | ByLayer | 8 | vozovka_chodník-spodní podkladní vrstva | Barva_8 | nerelevantni | D1.1.4 | ŠDA | ČSN 73 6126-1 | P2 | 128;128;128 | 7.5804 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | vozovka/chodník | 1078.97 | 1100 | spodní podkladní vrstva | 56330 | I1+S1+E1+Z1+M3;2&6+F1 | 0.25
zemní práce-rozprostření ornice (ohumusovani) | 93.5278 | 1 | no | ((-642596.111895208,-1062897.44693635,231.916650322426),(-642580.9079757,-1062887.65408676,232.845504992615)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 6.12457 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1026.85 | 1042.55 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
zemní práce-rozprostření ornice (ohumusovani) | 166.035 | 1 | no | ((-642549.711864554,-1062925.26535932,231.628526123628),(-642529.49506557,-1062912.12151994,232.836627322802)) | ByLayer | 73 | zemní práce-rozprostření ornice (ohumusovani) | Barva_73 | nerelevantni | D1.1.4 | ornice | nerelevantni | P100 | 165;207;99 | 11.2495 | řezová metoda | SO 101 | nerelevantni | PDPS | Přeložka silnice II/322 | OTSKP | zemní práce | 1078.97 | 1100 | rozprostření ornice (ohumusovani) | 18220 | I1+S1+E1+Z1+M3;2&6+F1 | 0.15
